	RBITFLD.LONG 0x00 31. "INT MASK , INT_MASK_STATUS"
	RBITFLD.LONG 0x00 30. " RAW , INT_RAW_STATUS"
	BITFLD.LONG 0x00 29. " CLR , INT_CLR"
	BITFLD.LONG 0x00 28. " EN , INT_EN"
	RBITFLD.LONG 0x00 2. " BW_EN , BW_CNT_ENABLE"
	BITFLD.LONG 0x00 1. " BUSY_EN , BUS_BUSY_DET_EN"
	BITFLD.LONG 0x00 0. " CHN_EN , CHN_EN"

