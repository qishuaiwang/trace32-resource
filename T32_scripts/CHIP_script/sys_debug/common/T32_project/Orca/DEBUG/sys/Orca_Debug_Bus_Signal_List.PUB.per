;This file is generated by Trace32PerBuilder Version:1.0.
config 16. 8.
width 42.
BASE EAPB:0x0
;###################Tree###################
TREE "PUB"
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_int_gen @ pub_dbg_mod_array_0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 0(0x0)" 
    VARX 0x00 %l SWD.read(0x00000008)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "         int_dfs_error ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "      int_dfs_complete ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "       int_hw_dfs_exit ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "            int_mem_fw ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "       int_dmc_mpu_vio ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "          int_dfs_deny ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "        int_dfs_giveup ," "0   ,%d..."
    BITFLD.LONG 0x00 22.--24. "           dfs_frq_sel ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 21. "             dfs_error ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "              dfs_resp ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "               dfs_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "               dfs_req ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 17. "  ddr_self_refresh_req ," "0   ,%d..."
    BITFLD.LONG 0x00 16. " ddr_self_refresh_flag ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "         dmc_sleep_ch0 ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "         dmc_sleep_ch1 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 13. "         dmc_sleep_ch2 ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "         dmc_sleep_ch3 ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "         dmc_sleep_ch4 ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "         dmc_sleep_ch5 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 9. "         dmc_sleep_ch6 ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "             dmc_sleep ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "           dmc_stop_ch ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "           dmc_stop_ch ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 5. "           dmc_stop_ch ," "0   ,%d..."
    BITFLD.LONG 0x00 4. "           dmc_stop_ch ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "           dmc_stop_ch ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "           dmc_stop_ch ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 1. "           dmc_stop_ch ," "0   ,%d..."
    BITFLD.LONG 0x00 0. "              dmc_stop ," "0   ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_dfs_deskew_ctrl @ pub_dbg_mod_array_1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 1(0x1)" 
    VARX 0x00 %l SWD.read(0x00000108)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "    dmc_clk_dfs_cgm_en ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "     dmc_clk_d2_cgm_en ," "0   ,%d..."
    BITFLD.LONG 0x00 26.--29. "  dmc_clk_hw_cur_state ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24.--25. "      dmc_cur_clk_mode ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "          dfs_clk_mode ," "0x0 ,%x..."
    BITFLD.LONG 0x00 21. "         DLL_PHASE_DEC ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "                  LOCK ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "            dfs_fc_req ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "            dfs_fc_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "          dfs_fc_req_o ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "          dfs_fc_ack_o ," "0   ,%d..."
    BITFLD.LONG 0x00 13.--15. "           dmc_ckg_sel ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 11.--12. "        dmc_ckg_d2_sel ," "0x0 ,%x..."
    BITFLD.LONG 0x00 9.--10. "        dmc_ckg_x1_sel ," "0x0 ,%x..."
    BITFLD.LONG 0x00 7.--8. "      dmc_ckg_clk_mode ," "0x0 ,%x..."
    BITFLD.LONG 0x00 6. " r_pll_pd_default_high ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 5. " dmc_sref_auto_gate_en ," "0   ,%d..."
    BITFLD.LONG 0x00 4. "        dmc_ext_clk_en ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "          pub_dfs_lock ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "        pub_sleep_lock ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 1. "        pub_dfs_lp_req ," "0   ,%d..."
    BITFLD.LONG 0x00 0. "       pub_dmc_dfs_req ," "0   ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top.u_qos_ctrl @ pub_dbg_mod_array_2"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 2(0x2)" 
    VARX 0x00 %l SWD.read(0x00000208)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_2 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 25.--31. "             qosc_port_busy ," "0x0  ,%x..."
    BITFLD.LONG 0x00 17.--24. "                   reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 16. "       cgm_busy_clk_pub_dfs ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "      cgm_busy_dfs_top_ctrl ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "   cgm_busy_dfs_deskew_ctrl ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "    cgm_busy_latmon_clk_dfs ," "0    ,%d..."
    BITFLD.LONG 0x00 12. " cgm_busy_clk_dmc_d2_dfimon ," "0    ,%d..."
    BITFLD.LONG 0x00 10.--11. "                   reserved ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 9. "       cgm_busy_lpc_pub_cfg ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "                   reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 7. "        cgm_busy_lpc_aonsys ," "0    ,%d..."
    BITFLD.LONG 0x00 6. "         cgm_busy_lpc_apcpu ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 5. "         cgm_busy_lpc_cssys ," "0    ,%d..."
    BITFLD.LONG 0x00 4. "        cgm_busy_lpc_miniap ," "0    ,%d..."
    BITFLD.LONG 0x00 1.--3. "                   reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 0. " cgm_busy_lpc_pub_merge_mtx ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_async_bridge_top_r_wrap_apcpu.u_async_bridge_top_r @ pub_dbg_mod_array_3_apcpu"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 3(0x3)" 
    VARX 0x00 %l SWD.read(0x00000308)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_3_apcpu "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "      reserved ," "0x0 ,%x..."
    BITFLD.LONG 0x00 29. "      RREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      RVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      BREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "      BVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "     ARREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "     ARVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "      WREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "      WVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "     AWREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "     AWVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "  r_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "  b_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  ar_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "   w_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "  aw_ch_r_full ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "   r_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "   b_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " ar_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "  w_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " aw_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. "            cs ," "0x0 ,%x..."
    BITFLD.LONG 0x00 6. "  async_config ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " fifo_sync_clr ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "       mask_en ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "      idle_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " idle_req_sync ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "      mask_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " mask_req_sync ," "0   ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_async_bridge_top_r_wrap_miniap.u_async_bridge_top_r @ pub_dbg_mod_array_4_apsys"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 4(0x4)" 
    VARX 0x00 %l SWD.read(0x00000408)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_4_apsys "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "      reserved ," "0x0 ,%x..."
    BITFLD.LONG 0x00 29. "      RREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      RVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      BREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "      BVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "     ARREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "     ARVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "      WREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "      WVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "     AWREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "     AWVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "  r_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "  b_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  ar_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "   w_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "  aw_ch_r_full ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "   r_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "   b_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " ar_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "  w_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " aw_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. "            cs ," "0x0 ,%x..."
    BITFLD.LONG 0x00 6. "  async_config ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " fifo_sync_clr ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "       mask_en ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "      idle_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " idle_req_sync ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "      mask_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " mask_req_sync ," "0   ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_async_bridge_top_r_wrap_cssys.u_async_bridge_top_r @ pub_dbg_mod_array_5_cssys"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 5(0x5)" 
    VARX 0x00 %l SWD.read(0x00000508)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_5_cssys "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "      reserved ," "0x0 ,%x..."
    BITFLD.LONG 0x00 29. "      RREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      RVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      BREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "      BVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "     ARREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "     ARVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "      WREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "      WVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "     AWREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "     AWVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "  r_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "  b_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  ar_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "   w_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "  aw_ch_r_full ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "   r_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "   b_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " ar_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "  w_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " aw_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. "            cs ," "0x0 ,%x..."
    BITFLD.LONG 0x00 6. "  async_config ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " fifo_sync_clr ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "       mask_en ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "      idle_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " idle_req_sync ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "      mask_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " mask_req_sync ," "0   ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_async_bridge_top_r_wrap_aonsys.u_async_bridge_top_r @ pub_dbg_mod_array_6_aonsys"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 6(0x6)" 
    VARX 0x00 %l SWD.read(0x00000608)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_6_aonsys "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "      reserved ," "0x0 ,%x..."
    BITFLD.LONG 0x00 29. "      RREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      RVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      BREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "      BVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "     ARREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "     ARVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "      WREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "      WVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "     AWREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "     AWVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "  r_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "  b_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  ar_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "   w_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "  aw_ch_r_full ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "   r_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "   b_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " ar_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "  w_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " aw_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. "            cs ," "0x0 ,%x..."
    BITFLD.LONG 0x00 6. "  async_config ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " fifo_sync_clr ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "       mask_en ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "      idle_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " idle_req_sync ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "      mask_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " mask_req_sync ," "0   ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_async_bridge_top_r_wrap_nrcpu.u_async_bridge_top_r @ pub_dbg_mod_array_7_nrcpu"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 7(0x7)" 
    VARX 0x00 %l SWD.read(0x00000708)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_7_nrcpu "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "      reserved ," "0x0 ,%x..."
    BITFLD.LONG 0x00 29. "      RREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      RVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      BREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "      BVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "     ARREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "     ARVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "      WREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "      WVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "     AWREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "     AWVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "  r_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "  b_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  ar_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "   w_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "  aw_ch_r_full ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "   r_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "   b_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " ar_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "  w_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " aw_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. "            cs ," "0x0 ,%x..."
    BITFLD.LONG 0x00 6. "  async_config ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " fifo_sync_clr ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "       mask_en ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "      idle_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " idle_req_sync ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "      mask_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " mask_req_sync ," "0   ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_async_bridge_top_r_wrap_nracc.u_async_bridge_top_r @ pub_dbg_mod_array_8_nracc"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 8(0x8)" 
    VARX 0x00 %l SWD.read(0x00000808)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_8_nracc "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "      reserved ," "0x0 ,%x..."
    BITFLD.LONG 0x00 29. "      RREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      RVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      BREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "      BVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "     ARREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "     ARVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "      WREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "      WVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "     AWREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "     AWVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "  r_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "  b_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  ar_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "   w_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "  aw_ch_r_full ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "   r_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "   b_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " ar_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "  w_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " aw_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. "            cs ," "0x0 ,%x..."
    BITFLD.LONG 0x00 6. "  async_config ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " fifo_sync_clr ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "       mask_en ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "      idle_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " idle_req_sync ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "      mask_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " mask_req_sync ," "0   ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_async_bridge_top_r_wrap_v3cpu.u_async_bridge_top_r @ pub_dbg_mod_array_9_v3cpu"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 9(0x9)" 
    VARX 0x00 %l SWD.read(0x00000908)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_9_v3cpu "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "      reserved ," "0x0 ,%x..."
    BITFLD.LONG 0x00 29. "      RREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      RVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      BREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "      BVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "     ARREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "     ARVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "      WREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "      WVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "     AWREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "     AWVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "  r_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "  b_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  ar_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "   w_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "  aw_ch_r_full ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "   r_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "   b_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " ar_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "  w_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " aw_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. "            cs ," "0x0 ,%x..."
    BITFLD.LONG 0x00 6. "  async_config ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " fifo_sync_clr ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "       mask_en ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "      idle_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " idle_req_sync ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "      mask_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " mask_req_sync ," "0   ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_async_bridge_top_r_wrap_v3acc.u_async_bridge_top_r @ pub_dbg_mod_array_10_v3acc"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 10(0xa)" 
    VARX 0x00 %l SWD.read(0x00000A08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_10_v3acc "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "      reserved ," "0x0 ,%x..."
    BITFLD.LONG 0x00 29. "      RREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      RVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      BREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "      BVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "     ARREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "     ARVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "      WREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "      WVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "     AWREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "     AWVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "  r_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "  b_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  ar_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "   w_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "  aw_ch_r_full ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "   r_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "   b_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " ar_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "  w_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " aw_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. "            cs ," "0x0 ,%x..."
    BITFLD.LONG 0x00 6. "  async_config ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " fifo_sync_clr ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "       mask_en ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "      idle_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " idle_req_sync ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "      mask_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " mask_req_sync ," "0   ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_async_bridge_top_r_wrap_pscp.u_async_bridge_top_r @ pub_dbg_mod_array_11_pscp"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 11(0xb)" 
    VARX 0x00 %l SWD.read(0x00000B08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_11_pscp "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "      reserved ," "0x0 ,%x..."
    BITFLD.LONG 0x00 29. "      RREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      RVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      BREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "      BVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "     ARREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "     ARVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "      WREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "      WVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "     AWREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "     AWVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "  r_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "  b_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  ar_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "   w_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "  aw_ch_r_full ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "   r_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "   b_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " ar_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "  w_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " aw_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. "            cs ," "0x0 ,%x..."
    BITFLD.LONG 0x00 6. "  async_config ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " fifo_sync_clr ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "       mask_en ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "      idle_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " idle_req_sync ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "      mask_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " mask_req_sync ," "0   ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_async_bridge_top_r_wrap_agcp.u_async_bridge_top_r @ pub_dbg_mod_array_12_audcp"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 12(0xc)" 
    VARX 0x00 %l SWD.read(0x00000C08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_12_audcp "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "      reserved ," "0x0 ,%x..."
    BITFLD.LONG 0x00 29. "      RREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      RVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      BREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "      BVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "     ARREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "     ARVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "      WREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "      WVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "     AWREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "     AWVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "  r_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "  b_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  ar_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "   w_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "  aw_ch_r_full ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "   r_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "   b_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " ar_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "  w_ch_r_empty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " aw_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. "            cs ," "0x0 ,%x..."
    BITFLD.LONG 0x00 6. "  async_config ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " fifo_sync_clr ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "       mask_en ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "      idle_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " idle_req_sync ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "      mask_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " mask_req_sync ," "0   ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_ch0 @ pub_dbg_mod_array_13"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 13(0xd)" 
    VARX 0x00 %l SWD.read(0x00000D08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_13 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 23.--31. "       deskew_dll_adjs ," "0x0   ,%x..."
    BITFLD.LONG 0x00 22. " deskew_dll_adjs_valid ," "0     ,%d..."
    BITFLD.LONG 0x00 21. "          rst_dmc_sc_n ," "0     ,%d..."
    BITFLD.LONG 0x00 20. "             rst_dmc_n ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "             dcc_rst_n ," "0     ,%d..."
    BITFLD.LONG 0x00 18. "             rst_phy_n ," "0     ,%d..."
    BITFLD.LONG 0x00 17. "      pub_mem_fw_cg_st ," "0     ,%d..."
    BITFLD.LONG 0x00 7.--16. "         pub_int_cg_st ," "0x0   ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--6. "              reserved ," "0x0   ,%x..."
    SGROUP " @ pub_dbg_mod_array_14"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 14(0xe)" 
    VARX 0x00 %l SWD.read(0x00000E08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_14 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "                      reserved ," "0x0 ,%x..."
    BITFLD.LONG 0x00 28.--29. "        monitor_wait_en_status ," "0x0 ,%x..."
    BITFLD.LONG 0x00 26.--27. "   monitor_gate_auto_en_status ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 25. "                  dfs_lock_req ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "                  dfs_lock_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "                   pll_lock_in ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "                  pll_lock_out ," "0   ,%d..."
    BITFLD.LONG 0x00 19.--21. "            ctrl_speed_set_sel ," "0x0 ,%x..."
    BITFLD.LONG 0x00 18. "                      reserved ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 17. "                      dcc_rstn ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "                      reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "                      rst_n_mc ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "               CHA_dll_lock_in ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "              CHA_dll_lock_out ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "       CHA_cst_gate_process_in ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 11. "      CHA_cst_gate_process_out ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "                      HCLK_cha ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "                   HRESETn_cha ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. "                    sre_io_cha ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "  phy_ac_dll_acc_max_pulse_cha ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "  phy_ac_dll_acc_min_pulse_cha ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 5. " phy_db0_dll_acc_max_pulse_cha ," "0   ,%d..."
    BITFLD.LONG 0x00 4. " phy_db0_dll_acc_min_pulse_cha ," "0   ,%d..."
    BITFLD.LONG 0x00 3. " phy_db1_dll_acc_max_pulse_cha ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 2. " phy_db1_dll_acc_min_pulse_cha ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "       dram_dfi_init_start_cha ," "0   ,%d..."
    BITFLD.LONG 0x00 0. "    dram_dfi_init_complete_cha ," "0   ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_ch0 @ pub_dbg_mod_array_15"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 15(0xf)" 
    VARX 0x00 %l SWD.read(0x00000F08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_15 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. "                      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 23. "                   ddrphy_iddq ," "0    ,%d..."
    BITFLD.LONG 0x00 22. "                     pd_pwr_on ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 21. "                        pd_ack ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "                        pd_iso ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "           deskew_dll_adjs_sat ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "               deskew_dll_lock ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "                deskew_dll_err ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "         deskew_dll_adjs_valid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "           deskew_dll_lock_1st ," "0    ,%d..."
    BITFLD.LONG 0x00 14. "               CHB_dll_lock_in ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "              CHB_dll_lock_out ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. "       CHB_cst_gate_process_in ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "      CHB_cst_gate_process_out ," "0    ,%d..."
    BITFLD.LONG 0x00 10. "                      HCLK_chb ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 9. "                   HRESETn_chb ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "                    sre_io_chb ," "0    ,%d..."
    BITFLD.LONG 0x00 7. "  phy_ac_dll_acc_max_pulse_chb ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 6. "  phy_ac_dll_acc_min_pulse_chb ," "0    ,%d..."
    BITFLD.LONG 0x00 5. " phy_db0_dll_acc_max_pulse_chb ," "0    ,%d..."
    BITFLD.LONG 0x00 4. " phy_db0_dll_acc_min_pulse_chb ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. " phy_db1_dll_acc_max_pulse_chb ," "0    ,%d..."
    BITFLD.LONG 0x00 2. " phy_db1_dll_acc_min_pulse_chb ," "0    ,%d..."
    BITFLD.LONG 0x00 1. "       dram_dfi_init_start_chb ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "    dram_dfi_init_complete_chb ," "0    ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_ch0 @ pub_dbg_mod_array_16"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 16(0x10)" 
    VARX 0x00 %l SWD.read(0x00001008)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_16 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 23.--31. "                    reserved ," "0x0   ,%x..."
    BITFLD.LONG 0x00 22. "          jitter_det_region0 ," "0     ,%d..."
    BITFLD.LONG 0x00 21. "          jitter_det_region4 ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 20. "              ctrl_rd_on_cha ," "0     ,%d..."
    BITFLD.LONG 0x00 19. "              ctrl_wr_on_cha ," "0     ,%d..."
    BITFLD.LONG 0x00 18. "             ctrl_cmd_on_cha ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 17. "            ctrl_busy_on_cha ," "0     ,%d..."
    BITFLD.LONG 0x00 16. "         dram_dfi_cs_n_p0[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 15. "         dram_dfi_cs_n_p1[0] ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "    dram_dfi_rddata_en_p0[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 13. "    dram_dfi_rddata_en_p1[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 12. " dram_dfi_rddata_valid_w0[0] ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 11. "    dram_dfi_wrdata_en_p0[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 10. "    dram_dfi_wrdata_en_p1[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 0.--9. "          dram_dfi_wrdata_p0 ," "0x0   ,%x..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_ch0 @ pub_dbg_mod_array_17"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 17(0x11)" 
    VARX 0x00 %l SWD.read(0x00001108)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_17 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 21.--31. "                    reserved ," "0x0   ,%x..."
    BITFLD.LONG 0x00 20. "              ctrl_rd_on_chb ," "0     ,%d..."
    BITFLD.LONG 0x00 19. "              ctrl_wr_on_chb ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "             ctrl_cmd_on_chb ," "0     ,%d..."
    BITFLD.LONG 0x00 17. "            ctrl_busy_on_chb ," "0     ,%d..."
    BITFLD.LONG 0x00 16. "         dram_dfi_cs_n_p0[0] ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "         dram_dfi_cs_n_p1[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 14. "    dram_dfi_rddata_en_p0[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 13. "    dram_dfi_rddata_en_p1[0] ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. " dram_dfi_rddata_valid_w0[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 11. "    dram_dfi_wrdata_en_p0[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 10. "    dram_dfi_wrdata_en_p1[0] ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--9. "          dram_dfi_rddata_w0 ," "0x0   ,%x..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_ch0 @ pub_dbg_mod_array_18"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 18(0x12)" 
    VARX 0x00 %l SWD.read(0x00001208)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_18 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. "            reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 20.--23. "  CHA_dbg_ac_dcc_fsm ," "0x0  ,%x..."
    BITFLD.LONG 0x00 16.--19. " CHA_dbg_db0_dcc_fsm ," "0x0  ,%x..."
    BITFLD.LONG 0x00 12.--15. " CHA_dbg_db1_dcc_fsm ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8.--11. "  CHB_dbg_ac_dcc_fsm ," "0x0  ,%x..."
    BITFLD.LONG 0x00 4.--7. " CHB_dbg_db0_dcc_fsm ," "0x0  ,%x..."
    BITFLD.LONG 0x00 0.--3. " CHB_dbg_db1_dcc_fsm ," "0x0  ,%x..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_ch0 @ pub_dbg_mod_array_19"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 19(0x13)" 
    VARX 0x00 %l SWD.read(0x00001308)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_19 ,reserved"
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_ch0 @ pub_dbg_mod_array_20"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 20(0x14)" 
    VARX 0x00 %l SWD.read(0x00001408)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_20 ,reserved"
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_ch0 @ pub_dbg_mod_array_21"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 21(0x15)" 
    VARX 0x00 %l SWD.read(0x00001508)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_21 ,reserved"
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top @ pub_dbg_mod_array_22"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 22(0x16)" 
    VARX 0x00 %l SWD.read(0x00001608)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_22 ,dmc_dbg_data"
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top @ pub_dbg_mod_array_23"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 23(0x17)" 
    VARX 0x00 %l SWD.read(0x00001708)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_23 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "         reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 29. "   arurgent_selm6 ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "   awurgent_selm6 ," "0    ,%d..."
    BITFLD.LONG 0x00 27. "   arurgent_selm5 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "   awurgent_selm5 ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "   arurgent_selm4 ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "   awurgent_selm4 ," "0    ,%d..."
    BITFLD.LONG 0x00 23. "   arurgent_selm3 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "   awurgent_selm3 ," "0    ,%d..."
    BITFLD.LONG 0x00 21. "   arurgent_selm2 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   awurgent_selm2 ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "   arurgent_selm1 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "   awurgent_selm1 ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "   arurgent_selm0 ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "   awurgent_selm0 ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "         reserved ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8.--14. " axi_port_rd_idle ," "0x0  ,%x..."
    BITFLD.LONG 0x00 7. "         reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--6. " axi_port_wr_idle ," "0x0  ,%x..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top @ pub_dbg_mod_array_24"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 24(0x18)" 
    VARX 0x00 %l SWD.read(0x00001808)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_24 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "              arurgents1 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 28.--29. "              awurgents1 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 26.--27. "              arurgents0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 24.--25. "              awurgents0 ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 23. "                reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 22. " bwmon_timer_start_v3acc ," "0    ,%d..."
    BITFLD.LONG 0x00 21. "    bwmon_f_up_req_v3acc ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "    bwmon_f_up_req_v3cpu ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "    bwmon_f_up_req_nracc ," "0    ,%d..."
    BITFLD.LONG 0x00 18. "    bwmon_f_up_req_nrcpu ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "   bwmon_f_up_req_miniap ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "    bwmon_f_up_req_apcpu ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. " latmon_timer_start_pscp ," "0    ,%d..."
    BITFLD.LONG 0x00 14. "     latmon_dfs_req_pscp ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "    latmon_dfs_req_v3acc ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "    latmon_dfs_req_v3cpu ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 11. "    latmon_dfs_req_nracc ," "0    ,%d..."
    BITFLD.LONG 0x00 10. "    latmon_dfs_req_nrcpu ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "   latmon_dfs_req_miniap ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "    latmon_dfs_req_apcpu ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "                reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--6. "           axi_port_idle ," "0x0  ,%x..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top @ pub_dbg_mod_array_25"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 25(0x19)" 
    VARX 0x00 %l SWD.read(0x00001908)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_25 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "  latmon_urgency_rd_nrcpu ," "0x0 ,%x..."
    BITFLD.LONG 0x00 28.--29. "  latmon_urgency_wr_nrcpu ," "0x0 ,%x..."
    BITFLD.LONG 0x00 26.--27. " latmon_urgency_rd_miniap ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24.--25. " latmon_urgency_wr_miniap ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "  latmon_urgency_rd_apcpu ," "0x0 ,%x..."
    BITFLD.LONG 0x00 20.--21. "  latmon_urgency_wr_apcpu ," "0x0 ,%x..."
    BITFLD.LONG 0x00 18.--19. "               arurgents6 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 16.--17. "               awurgents6 ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14.--15. "               arurgents5 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 12.--13. "               awurgents5 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 10.--11. "               arurgents4 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 8.--9. "               awurgents4 ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 6.--7. "               arurgents3 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 4.--5. "               awurgents3 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 2.--3. "               arurgents2 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 0.--1. "               awurgents2 ," "0x0 ,%x..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top @ pub_dbg_mod_array_26"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 26(0x1a)" 
    VARX 0x00 %l SWD.read(0x00001A08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_26 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "                       reserved ," "0x0 ,%x..."
    BITFLD.LONG 0x00 29. "   latency_actual_ov_st_rd_pscp ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "   latency_actual_ov_st_wr_pscp ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "  latency_actual_ov_st_rd_v3acc ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "  latency_actual_ov_st_wr_v3acc ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "  latency_actual_ov_st_rd_v3cpu ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 24. "  latency_actual_ov_st_wr_v3cpu ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "  latency_actual_ov_st_rd_v3acc ," "0   ,%d..."
    BITFLD.LONG 0x00 22. "  latency_actual_ov_st_wr_v3acc ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 21. "  latency_actual_ov_st_rd_nrcpu ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "  latency_actual_ov_st_wr_nrcpu ," "0   ,%d..."
    BITFLD.LONG 0x00 19. " latency_actual_ov_st_rd_miniap ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. " latency_actual_ov_st_wr_miniap ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  latency_actual_ov_st_rd_apcpu ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "  latency_actual_ov_st_wr_apcpu ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14.--15. "         latmon_urgency_rd_pscp ," "0x0 ,%x..."
    BITFLD.LONG 0x00 12.--13. "         latmon_urgency_wr_pscp ," "0x0 ,%x..."
    BITFLD.LONG 0x00 10.--11. "        latmon_urgency_rd_v3acc ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8.--9. "        latmon_urgency_wr_v3acc ," "0x0 ,%x..."
    BITFLD.LONG 0x00 6.--7. "        latmon_urgency_rd_v3cpu ," "0x0 ,%x..."
    BITFLD.LONG 0x00 4.--5. "        latmon_urgency_wr_v3cpu ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 2.--3. "        latmon_urgency_rd_nracc ," "0x0 ,%x..."
    BITFLD.LONG 0x00 0.--1. "        latmon_urgency_wr_nracc ," "0x0 ,%x..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top @ pub_dbg_mod_array_27"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 27(0x1b)" 
    VARX 0x00 %l SWD.read(0x00001B08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_27 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "   latency_target_rd_apcpu[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 24.--30. " latency_target_rd_apcpu[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 23. "   latency_actual_rd_apcpu[30] ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--22. " latency_actual_rd_apcpu[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 15. "   latency_target_wr_apcpu[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--14. " latency_target_wr_apcpu[11:5] ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "   latency_actual_wr_apcpu[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--6. " latency_actual_wr_apcpu[11:5] ," "0x0  ,%x..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_dfs_deskew_ctrl @ pub_dbg_mod_array_28"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 28(0x1c)" 
    VARX 0x00 %l SWD.read(0x00001C08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_28 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "          dmc_clk_x2_cgm_en ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "       dmc_clk_pd_d2_cgm_en ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "             cgm_en_clk_dmc ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "       cgm_busy_clk_dmc_ref ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "       cgm_busy_clk_aon_apb ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "         cgm_busy_clk_cssys ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       cgm_busy_lpc_pub_cfg ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       cgm_busy_all_ddrc_ch ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 23. "         cgm_busy_ddr_umctl ," "0    ,%d..."
    BITFLD.LONG 0x00 22. "         ddr_clk_auto_en_or ," "0    ,%d..."
    BITFLD.LONG 0x00 21. "       cgm_busy_clk_pub_dfs ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "           pub_dfs_sleep_on ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. " pub_clk_dfs_lp_ctrl_cgm_en ," "0    ,%d..."
    BITFLD.LONG 0x00 18. "    pub_clk_dfs_ctrl_cgm_en ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "  pub_clk_dfs_deskew_cgm_en ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "    pub_clk_dfs_tick_cgm_en ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "      cgm_busy_vote_pub_dfs ," "0    ,%d..."
    BITFLD.LONG 0x00 14. "            dpll0_clkout_en ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "         st_dpll0_clkout_en ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "            dpll1_clkout_en ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 11. "         st_dpll1_clkout_en ," "0    ,%d..."
    BITFLD.LONG 0x00 10. "             cgm_pub_dfs_en ," "0    ,%d..."
    BITFLD.LONG 0x00 5.--9. "           hw_dfs_fsm_state ," "0x0  ,%x..."
    BITFLD.LONG 0x00 4. "      dmc_clk_init_sw_start ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. "       dmc_clk_init_sw_done ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--2. "           dfs_sw_fsm_state ," "0x0  ,%x..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_dfs_lp_ctrl @ pub_dbg_mod_array_29"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 29(0x1d)" 
    VARX 0x00 %l SWD.read(0x00001D08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_29 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "                   dmc_sleep ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "          axi_chn_stop_apcpu ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "         axi_chn_stop_miniap ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 28. "          axi_chn_stop_cssys ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "         axi_chn_stop_aonsys ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "          axi_chn_stop_nrcpu ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 25. "          axi_chn_stop_nracc ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "          axi_chn_stop_v3cpu ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "          axi_chn_stop_v3acc ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "           axi_chn_stop_pscp ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "           axi_chn_stop_agcp ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "              cgm_en_dmc_ch0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "              cgm_en_dmc_ch1 ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "              cgm_en_dmc_ch2 ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "              cgm_en_dmc_ch3 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "              cgm_en_dmc_ch4 ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "              cgm_en_dmc_ch5 ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "              cgm_en_dmc_ch6 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 13. "                    reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "           ch0_dmc_phy_ag_en ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "        ch0_dmc_phy_ag_wr_en ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        ch0_dmc_phy_ag_rd_en ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "           ch0_dmc_phy_ca_en ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "           ch1_dmc_phy_ag_en ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "        ch1_dmc_phy_ag_wr_en ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "        ch1_dmc_phy_ag_rd_en ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "           ch1_dmc_phy_ca_en ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "              pub_deep_sleep ," "0   ,%d..."
    BITFLD.LONG 0x00 3. " chip_clk_switch_for_leakage ," "0   ,%d..."
    BITFLD.LONG 0x00 0.--2. "       dmc_phy_speed_set_sel ," "0x0 ,%x..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_dfs_top_ctrl_ddr @ pub_dbg_mod_array_30"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 30(0x1e)" 
    VARX 0x00 %l SWD.read(0x00001E08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_30 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 25.--31. "           emc_ckg_sel ," "0x0   ,%x..."
    BITFLD.LONG 0x00 21.--24. "        emc_ckg_d2_sel ," "0x0   ,%x..."
    BITFLD.LONG 0x00 19.--20. "          emc_ckg_mode ," "0x0   ,%x..."
    BITFLD.LONG 0x00 10.--18. "      emc_ckg_ddl_adjs ," "0x0   ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 9. "     dmc_sleep_release ," "0     ,%d..."
    BITFLD.LONG 0x00 8. "      dmc_sleep_finish ," "0     ,%d..."
    BITFLD.LONG 0x00 7. "          dmc_clk_stop ," "0     ,%d..."
    BITFLD.LONG 0x00 4.--6. " dfs_lp_ctrl_cur_state ," "0x0   ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. "                bv_req ," "0     ,%d..."
    BITFLD.LONG 0x00 2. "                fv_req ," "0     ,%d..."
    BITFLD.LONG 0x00 1. "            bv_release ," "0     ,%d..."
    BITFLD.LONG 0x00 0. "            fv_release ," "0     ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_dfs_top_ctrl_ddr @ pub_dbg_mod_array_31"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 31(0x1f)" 
    VARX 0x00 %l SWD.read(0x00001F08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_31 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 28.--31. "  vote_cur_state ," "0x0    ,%x..."
    BITFLD.LONG 0x00 24.--27. " vote_next_state ," "0x0    ,%x..."
    BITFLD.LONG 0x00 10.--23. "        reserved ," "0x0    ,%x..."
    BITFLD.LONG 0x00 9. "    bv_st_change ," "0      ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. "    fv_st_change ," "0      ,%d..."
    BITFLD.LONG 0x00 0.--7. "     gt_f_status ," "0x0    ,%x..."
    SGROUP " @ pub_dbg_mod_array_32"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 32(0x20)" 
    VARX 0x00 %l SWD.read(0x00002008)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_32 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "  reserved ," "0      ,%d..."
    BITFLD.LONG 0x00 16.--30. " bv_st_all ," "0x0    ,%x..."
    BITFLD.LONG 0x00 15. "  reserved ," "0      ,%d..."
    BITFLD.LONG 0x00 0.--14. " fv_st_all ," "0x0    ,%x..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top @ pub_dbg_mod_array_33"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 33(0x21)" 
    VARX 0x00 %l SWD.read(0x00002108)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_33 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "   latency_target_rd_miniap[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 24.--30. " latency_target_rd_miniap[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 23. "   latency_actual_rd_miniap[30] ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--22. " latency_actual_rd_miniap[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 15. "   latency_target_wr_miniap[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--14. " latency_target_wr_miniap[11:5] ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "   latency_actual_wr_miniap[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--6. " latency_actual_wr_miniap[11:5] ," "0x0  ,%x..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top @ pub_dbg_mod_array_34"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 34(0x22)" 
    VARX 0x00 %l SWD.read(0x00002208)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_34 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "   latency_target_rd_nrcpu[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 24.--30. " latency_target_rd_nrcpu[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 23. "   latency_actual_rd_nrcpu[30] ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--22. " latency_actual_rd_nrcpu[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 15. "   latency_target_wr_nrcpu[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--14. " latency_target_wr_nrcpu[11:5] ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "   latency_actual_wr_nrcpu[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--6. " latency_actual_wr_nrcpu[11:5] ," "0x0  ,%x..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top @ pub_dbg_mod_array_35"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 35(0x23)" 
    VARX 0x00 %l SWD.read(0x00002308)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_35 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "   latency_target_rd_nracc[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 24.--30. " latency_target_rd_nracc[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 23. "   latency_actual_rd_nracc[30] ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--22. " latency_actual_rd_nracc[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 15. "   latency_target_wr_nracc[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--14. " latency_target_wr_nracc[11:5] ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "   latency_actual_wr_nracc[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--6. " latency_actual_wr_nracc[11:5] ," "0x0  ,%x..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top @ pub_dbg_mod_array_36"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 36(0x24)" 
    VARX 0x00 %l SWD.read(0x00002408)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_36 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "   latency_target_rd_v3cpu[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 24.--30. " latency_target_rd_v3cpu[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 23. "   latency_actual_rd_v3cpu[30] ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--22. " latency_actual_rd_v3cpu[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 15. "   latency_target_wr_v3cpu[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--14. " latency_target_wr_v3cpu[11:5] ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "   latency_actual_wr_v3cpu[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--6. " latency_actual_wr_v3cpu[11:5] ," "0x0  ,%x..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top @ pub_dbg_mod_array_37"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 37(0x25)" 
    VARX 0x00 %l SWD.read(0x00002508)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_37 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "   latency_target_rd_v3acc[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 24.--30. " latency_target_rd_v3acc[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 23. "   latency_actual_rd_v3acc[30] ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--22. " latency_actual_rd_v3acc[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 15. "   latency_target_wr_v3acc[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--14. " latency_target_wr_v3acc[11:5] ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "   latency_actual_wr_v3acc[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--6. " latency_actual_wr_v3acc[11:5] ," "0x0  ,%x..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top @ pub_dbg_mod_array_38"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 38(0x26)" 
    VARX 0x00 %l SWD.read(0x00002608)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_38 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "   latency_target_rd_pscp[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 24.--30. " latency_target_rd_pscp[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 23. "   latency_actual_rd_pscp[30] ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--22. " latency_actual_rd_pscp[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 15. "   latency_target_wr_pscp[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--14. " latency_target_wr_pscp[11:5] ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "   latency_actual_wr_pscp[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--6. " latency_actual_wr_pscp[11:5] ," "0x0  ,%x..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_merge_mtx_wrap.u_axi_trans_mon_s0 @ pub_dbg_mod_array_39"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 39(0x27)" 
    VARX 0x00 %l SWD.read(0x00002708)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_39 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_merge_mtx_wrap.u_axi_trans_mon_s0 @ pub_dbg_mod_array_40"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 40(0x28)" 
    VARX 0x00 %l SWD.read(0x00002808)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_40 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "         r_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_merge_mtx_wrap.u_axi_trans_mon_m3 @ pub_dbg_mod_array_41"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 41(0x29)" 
    VARX 0x00 %l SWD.read(0x00002908)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_41 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_merge_mtx_wrap.u_axi_trans_mon_m3 @ pub_dbg_mod_array_42"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 42(0x2a)" 
    VARX 0x00 %l SWD.read(0x00002A08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_42 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "         r_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_merge_mtx_wrap.u_axi_trans_mon_m2 @ pub_dbg_mod_array_43"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 43(0x2b)" 
    VARX 0x00 %l SWD.read(0x00002B08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_43 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_merge_mtx_wrap.u_axi_trans_mon_m2 @ pub_dbg_mod_array_44"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 44(0x2c)" 
    VARX 0x00 %l SWD.read(0x00002C08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_44 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "         r_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_merge_mtx_wrap.u_axi_trans_mon_m1 @ pub_dbg_mod_array_45"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 45(0x2d)" 
    VARX 0x00 %l SWD.read(0x00002D08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_45 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_merge_mtx_wrap.u_axi_trans_mon_m1 @ pub_dbg_mod_array_46"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 46(0x2e)" 
    VARX 0x00 %l SWD.read(0x00002E08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_46 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "         r_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_merge_mtx_wrap.u_axi_trans_mon_m0 @ pub_dbg_mod_array_47"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 47(0x2f)" 
    VARX 0x00 %l SWD.read(0x00002F08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_47 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_merge_mtx_wrap.u_axi_trans_mon_m0 @ pub_dbg_mod_array_48"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 48(0x30)" 
    VARX 0x00 %l SWD.read(0x00003008)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_48 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "         r_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_merge_mtx_wrap @ pub_dbg_mod_array_49"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 49(0x31)" 
    VARX 0x00 %l SWD.read(0x00003108)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_49 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 20.--31. "      reserved ," "0x0   ,%x..."
    BITFLD.LONG 0x00 19. "      reserved ," "0     ,%d..."
    BITFLD.LONG 0x00 18. " cactive_cd_m0 ," "0     ,%d..."
    BITFLD.LONG 0x00 17. " csysack_cd_m0 ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. " csysreq_cd_m0 ," "0     ,%d..."
    BITFLD.LONG 0x00 15. "      reserved ," "0     ,%d..."
    BITFLD.LONG 0x00 14. " cactive_cd_m1 ," "0     ,%d..."
    BITFLD.LONG 0x00 13. " csysack_cd_m1 ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. " csysreq_cd_m1 ," "0     ,%d..."
    BITFLD.LONG 0x00 11. "      reserved ," "0     ,%d..."
    BITFLD.LONG 0x00 10. " cactive_cd_m2 ," "0     ,%d..."
    BITFLD.LONG 0x00 9. " csysack_cd_m2 ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. " csysreq_cd_m2 ," "0     ,%d..."
    BITFLD.LONG 0x00 7. "      reserved ," "0     ,%d..."
    BITFLD.LONG 0x00 6. " cactive_cd_m3 ," "0     ,%d..."
    BITFLD.LONG 0x00 5. " csysack_cd_m3 ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. " csysreq_cd_m3 ," "0     ,%d..."
    BITFLD.LONG 0x00 3. "      reserved ," "0     ,%d..."
    BITFLD.LONG 0x00 2. " cactive_cd_s0 ," "0     ,%d..."
    BITFLD.LONG 0x00 1. " csysack_cd_s0 ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " csysreq_cd_s0 ," "0     ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cfg_mtx_wrap.u_apb_trans_mon_s4 @ pub_dbg_mod_array_50"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 50(0x32)" 
    VARX 0x00 %l SWD.read(0x00003208)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_50 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 20.--31. " reserved ," "0x0   ,%x..."
    BITFLD.LONG 0x00 19. "     psel ," "0     ,%d..."
    BITFLD.LONG 0x00 18. "  penable ," "0     ,%d..."
    BITFLD.LONG 0x00 17. "   pwrite ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "   pready ," "0     ,%d..."
    BITFLD.LONG 0x00 8.--15. "   rd_cnt ," "0     ,%d..."
    BITFLD.LONG 0x00 0.--7. "   wr_cnt ," "0     ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cfg_mtx_wrap.u_apb_trans_mon_s3 @ pub_dbg_mod_array_51"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 51(0x33)" 
    VARX 0x00 %l SWD.read(0x00003308)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_51 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 20.--31. " reserved ," "0x0   ,%x..."
    BITFLD.LONG 0x00 19. "     psel ," "0     ,%d..."
    BITFLD.LONG 0x00 18. "  penable ," "0     ,%d..."
    BITFLD.LONG 0x00 17. "   pwrite ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "   pready ," "0     ,%d..."
    BITFLD.LONG 0x00 8.--15. "   rd_cnt ," "0     ,%d..."
    BITFLD.LONG 0x00 0.--7. "   wr_cnt ," "0     ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cfg_mtx_wrap.u_apb_trans_mon_s2 @ pub_dbg_mod_array_52"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 52(0x34)" 
    VARX 0x00 %l SWD.read(0x00003408)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_52 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 20.--31. " reserved ," "0x0   ,%x..."
    BITFLD.LONG 0x00 19. "     psel ," "0     ,%d..."
    BITFLD.LONG 0x00 18. "  penable ," "0     ,%d..."
    BITFLD.LONG 0x00 17. "   pwrite ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "   pready ," "0     ,%d..."
    BITFLD.LONG 0x00 8.--15. "   rd_cnt ," "0     ,%d..."
    BITFLD.LONG 0x00 0.--7. "   wr_cnt ," "0     ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cfg_mtx_wrap.u_apb_trans_mon_s1 @ pub_dbg_mod_array_53"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 53(0x35)" 
    VARX 0x00 %l SWD.read(0x00003508)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_53 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 20.--31. " reserved ," "0x0   ,%x..."
    BITFLD.LONG 0x00 19. "     psel ," "0     ,%d..."
    BITFLD.LONG 0x00 18. "  penable ," "0     ,%d..."
    BITFLD.LONG 0x00 17. "   pwrite ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "   pready ," "0     ,%d..."
    BITFLD.LONG 0x00 8.--15. "   rd_cnt ," "0     ,%d..."
    BITFLD.LONG 0x00 0.--7. "   wr_cnt ," "0     ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cfg_mtx_wrap.u_ahb_trans_mon_s0 @ pub_dbg_mod_array_54"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 54(0x36)" 
    VARX 0x00 %l SWD.read(0x00003608)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_54 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--31. " reserved ," "0x0   ,%x..."
    BITFLD.LONG 0x00 21. " bus_idle ," "0     ,%d..."
    BITFLD.LONG 0x00 20. "     hsel ," "0     ,%d..."
    BITFLD.LONG 0x00 18.--19. "   htrans ," "0x0   ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 17. "   hwrite ," "0     ,%d..."
    BITFLD.LONG 0x00 16. "   hready ," "0     ,%d..."
    BITFLD.LONG 0x00 8.--15. "   rd_cnt ," "0     ,%d..."
    BITFLD.LONG 0x00 0.--7. "   wr_cnt ," "0     ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cfg_mtx_wrap.u_axi_trans_mon_m0 @ pub_dbg_mod_array_55"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 55(0x37)" 
    VARX 0x00 %l SWD.read(0x00003708)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_55 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cfg_mtx_wrap.u_axi_trans_mon_m0 @ pub_dbg_mod_array_56"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 56(0x38)" 
    VARX 0x00 %l SWD.read(0x00003808)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_56 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "         r_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cfg_mtx_wrap @ pub_dbg_mod_array_57"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 57(0x39)" 
    VARX 0x00 %l SWD.read(0x00003908)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_57 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 23. "      reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 22. " cactive_cd_m0 ," "0    ,%d..."
    BITFLD.LONG 0x00 21. " csysack_cd_m0 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 20. " csysreq_cd_m0 ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "      reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 18. " cactive_cd_s0 ," "0    ,%d..."
    BITFLD.LONG 0x00 17. " csysack_cd_s0 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. " csysreq_cd_s0 ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "      reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 14. " cactive_cd_s1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. " csysack_cd_s1 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. " csysreq_cd_s1 ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "      reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 10. " cactive_cd_s2 ," "0    ,%d..."
    BITFLD.LONG 0x00 9. " csysack_cd_s2 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. " csysreq_cd_s2 ," "0    ,%d..."
    BITFLD.LONG 0x00 7. "      reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 6. " cactive_cd_s3 ," "0    ,%d..."
    BITFLD.LONG 0x00 5. " csysack_cd_s3 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. " csysreq_cd_s3 ," "0    ,%d..."
    BITFLD.LONG 0x00 3. "      reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 2. " cactive_cd_s4 ," "0    ,%d..."
    BITFLD.LONG 0x00 1. " csysack_cd_s4 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " csysreq_cd_s4 ," "0    ,%d..."
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cross_mtx_wrap.u_axi_trans_mon_m6 @ pub_dbg_mod_array_58"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 58(0x3a)" 
    VARX 0x00 %l SWD.read(0x00003A08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_58 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cross_mtx_wrap.u_axi_trans_mon_m6 @ pub_dbg_mod_array_59"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 59(0x3b)" 
    VARX 0x00 %l SWD.read(0x00003B08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_59 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "         r_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cross_mtx_wrap.u_axi_trans_mon_m5 @ pub_dbg_mod_array_60"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 60(0x3c)" 
    VARX 0x00 %l SWD.read(0x00003C08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_60 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cross_mtx_wrap.u_axi_trans_mon_m5 @ pub_dbg_mod_array_61"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 61(0x3d)" 
    VARX 0x00 %l SWD.read(0x00003D08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_61 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "         r_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cross_mtx_wrap.u_axi_trans_mon_m4 @ pub_dbg_mod_array_62"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 62(0x3e)" 
    VARX 0x00 %l SWD.read(0x00003E08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_62 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cross_mtx_wrap.u_axi_trans_mon_m4 @ pub_dbg_mod_array_63"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 63(0x3f)" 
    VARX 0x00 %l SWD.read(0x00003F08)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_63 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "         r_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cross_mtx_wrap.u_axi_trans_mon_m3 @ pub_dbg_mod_array_64"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 64(0x40)" 
    VARX 0x00 %l SWD.read(0x00004008)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_64 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cross_mtx_wrap.u_axi_trans_mon_m3 @ pub_dbg_mod_array_65"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 65(0x41)" 
    VARX 0x00 %l SWD.read(0x00004108)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_65 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "         r_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cross_mtx_wrap.u_axi_trans_mon_m2 @ pub_dbg_mod_array_66"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 66(0x42)" 
    VARX 0x00 %l SWD.read(0x00004208)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_66 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cross_mtx_wrap.u_axi_trans_mon_m2 @ pub_dbg_mod_array_67"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 67(0x43)" 
    VARX 0x00 %l SWD.read(0x00004308)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_67 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "         r_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cross_mtx_wrap.u_axi_trans_mon_m1 @ pub_dbg_mod_array_68"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 68(0x44)" 
    VARX 0x00 %l SWD.read(0x00004408)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_68 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cross_mtx_wrap.u_axi_trans_mon_m1 @ pub_dbg_mod_array_69"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 69(0x45)" 
    VARX 0x00 %l SWD.read(0x00004508)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_69 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "         r_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cross_mtx_wrap.u_axi_trans_mon_m0 @ pub_dbg_mod_array_70"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 70(0x46)" 
    VARX 0x00 %l SWD.read(0x00004608)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_70 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_pub.u_pub_top_inter_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pub_cross_mtx_wrap.u_axi_trans_mon_m0 @ pub_dbg_mod_array_71"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 71(0x47)" 
    VARX 0x00 %l SWD.read(0x00004708)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_mod_array_71 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "         r_cnt ," "0    ,%d..."
    TEXTLINE ""
TREE.END
