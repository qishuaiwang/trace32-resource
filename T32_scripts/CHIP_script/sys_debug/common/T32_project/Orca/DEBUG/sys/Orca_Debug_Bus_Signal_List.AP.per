;This file is generated by Trace32PerBuilder Version:1.0.
config 16. 8.
width 53.
BASE EAPB:0x0
;###################Tree###################
TREE "AP"
    SGROUP " @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 0(0x0)" 
    VARX 0x00 %l SWD.read(0x00000000)
    TEXTLINE ""
    LINE.LONG 0x00 "  ,reserved"
    TEXTLINE ""
    SGROUP " @ ap_dbg_bus_0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 1(0x1)" 
    VARX 0x00 %l SWD.read(0x00000100)
    TEXTLINE ""
    LINE.LONG 0x00 " ap_dbg_bus_0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "         reserved ," "0x0 ,%x..."
    BITFLD.LONG 0x00 29. " dma_act_light_en ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "         dma_busy ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      emmc_32k_eb ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "          emmc_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "  sdio_mst_32k_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "      sdio_mst_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "      usb0_ref_eb ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "  usb0_suspend_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "          usb0_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "          dma_eb2 ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "           dma_eb ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "     nandc_26m_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "     nandc_ecc_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "         nandc_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "           ckg_eb ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "    mmtx_m0_lp_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "    mmtx_m1_lp_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "    mmtx_m2_lp_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "    mmtx_m3_lp_eb ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "    mmtx_m4_lp_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "    mmtx_m5_lp_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "    mmtx_m6_lp_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "  mmtx_main_lp_eb ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 6. "    mmtx_s0_lp_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "    mmtx_s1_lp_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 4. "    mmtx_s2_lp_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "    mmtx_s3_lp_eb ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 2. "    mmtx_s4_lp_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "    mmtx_s5_lp_eb ," "0   ,%d..."
    BITFLD.LONG 0x00 0. "    mmtx_s6_lp_eb ," "0   ,%d..."
    SGROUP "u_sys_ap.u_ap_top.u_ahb_rf @ ap_dbg_bus_1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 2(0x2)" 
    VARX 0x00 %l SWD.read(0x00000200)
    TEXTLINE ""
    LINE.LONG 0x00 " ap_dbg_bus_1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "                  reserved ," "0x0 ,%x..."
    BITFLD.LONG 0x00 29. "      pcie_aux_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "  usb1_suspend_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      usb1_ref_clk_frc_off ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "  usb0_suspend_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "      usb0_ref_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "         nandc_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "     nandc_ecc_clk_frc_off ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "     nandc_26m_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "          emmc_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "      emmc_32k_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "      sdio_slv_clk_frc_off ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. " sdio_slv_frun_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "      sdio_mst_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "  sdio_mst_32k_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "      sim0_32k_clk_frc_off ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "          sim0_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "          pwm3_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "          pwm2_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "          pwm1_clk_frc_off ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "          pwm0_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "          spi2_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "          spi1_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "          spi0_clk_frc_off ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 6. "          i2c4_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "          i2c3_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 4. "          i2c2_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "          i2c1_clk_frc_off ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 2. "          i2c0_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "         uart0_clk_frc_off ," "0   ,%d..."
    BITFLD.LONG 0x00 0. "        ap_apb_clk_frc_off ," "0   ,%d..."
    SGROUP "u_sys_ap.u_ap_top.u_ahb_rf @ ap_dbg_bus_2"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 3(0x3)" 
    VARX 0x00 %l SWD.read(0x00000300)
    TEXTLINE ""
    LINE.LONG 0x00 " ap_dbg_bus_2 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "                 reserved ," "0x0 ,%x..."
    BITFLD.LONG 0x00 29. "      pcie_aux_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "  usb1_suspend_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      usb1_ref_clk_frc_on ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "  usb0_suspend_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "      usb0_ref_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "         nandc_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "     nandc_ecc_clk_frc_on ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "     nandc_26m_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "          emmc_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "      emmc_32k_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "      sdio_slv_clk_frc_on ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. " sdio_slv_frun_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "      sdio_mst_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "  sdio_mst_32k_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "      sim0_32k_clk_frc_on ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "          sim0_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "          pwm3_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "          pwm2_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "          pwm1_clk_frc_on ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "          pwm0_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "          spi2_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "          spi1_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "          spi0_clk_frc_on ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 6. "          i2c4_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "          i2c3_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 4. "          i2c2_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "          i2c1_clk_frc_on ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 2. "          i2c0_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "         uart0_clk_frc_on ," "0   ,%d..."
    BITFLD.LONG 0x00 0. "        ap_apb_clk_frc_on ," "0   ,%d..."
    SGROUP "u_sys_ap.u_ap_top @ ap_dbg_bus_3"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 4(0x4)" 
    VARX 0x00 %l SWD.read(0x00000400)
    TEXTLINE ""
    LINE.LONG 0x00 " ap_dbg_bus_3 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 21.--31. "        reserved ," "0x0   ,%x..."
    BITFLD.LONG 0x00 20. "     sim0_32k_eb ," "0     ,%d..."
    BITFLD.LONG 0x00 19. "         sim0_eb ," "0     ,%d..."
    BITFLD.LONG 0x00 18. "         pwm3_eb ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 17. "         pwm2_eb ," "0     ,%d..."
    BITFLD.LONG 0x00 16. "         pwm1_eb ," "0     ,%d..."
    BITFLD.LONG 0x00 15. "         pwm0_eb ," "0     ,%d..."
    BITFLD.LONG 0x00 14. "         spi2_eb ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 13. "         spi1_eb ," "0     ,%d..."
    BITFLD.LONG 0x00 12. "         spi0_eb ," "0     ,%d..."
    BITFLD.LONG 0x00 11. "         i2c4_eb ," "0     ,%d..."
    BITFLD.LONG 0x00 10. "         i2c3_eb ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 9. "         i2c2_eb ," "0     ,%d..."
    BITFLD.LONG 0x00 8. "         i2c1_eb ," "0     ,%d..."
    BITFLD.LONG 0x00 7. "         i2c0_eb ," "0     ,%d..."
    BITFLD.LONG 0x00 6. "        uart0_eb ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--5. " bus_busy_busmon ," "0x0   ,%x..."
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_lpc @ mmtx_lpc_dbg_out_2"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 5(0x5)" 
    VARX 0x00 %l SWD.read(0x00000500)
    TEXTLINE ""
    LINE.LONG 0x00 " mmtx_lpc_dbg_out_2 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 6.--31. "              reserved ," "0x0       ,%x..."
    BITFLD.LONG 0x00 5. " cgm_busy_mmtx_lpc_all ," "0         ,%d..."
    BITFLD.LONG 0x00 4. "     cgm_busy_lpc_main ," "0         ,%d..."
    BITFLD.LONG 0x00 3. "  cgm_busy_lpc_mmtx_m0 ," "0         ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 2. "  cgm_busy_lpc_mmtx_m1 ," "0         ,%d..."
    BITFLD.LONG 0x00 1. "  cgm_busy_lpc_mmtx_m2 ," "0         ,%d..."
    BITFLD.LONG 0x00 0. "  cgm_busy_lpc_mmtx_m3 ," "0         ,%d..."
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_lpc @ mmtx_lpc_dbg_out_1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 6(0x6)" 
    VARX 0x00 %l SWD.read(0x00000600)
    TEXTLINE ""
    LINE.LONG 0x00 " mmtx_lpc_dbg_out_1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " cgm_busy_lpc_mmtx_m4 ," "0   ,%d..."
    BITFLD.LONG 0x00 30. " cgm_busy_lpc_mmtx_m5 ," "0   ,%d..."
    BITFLD.LONG 0x00 29. " cgm_busy_lpc_mmtx_m6 ," "0   ,%d..."
    BITFLD.LONG 0x00 28. " cgm_busy_lpc_mmtx_s0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. " cgm_busy_lpc_mmtx_s1 ," "0   ,%d..."
    BITFLD.LONG 0x00 26. " cgm_busy_lpc_mmtx_s2 ," "0   ,%d..."
    BITFLD.LONG 0x00 25. " cgm_busy_lpc_mmtx_s3 ," "0   ,%d..."
    BITFLD.LONG 0x00 24. " cgm_busy_lpc_mmtx_s4 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 23. " cgm_busy_lpc_mmtx_s5 ," "0   ,%d..."
    BITFLD.LONG 0x00 22. " cgm_busy_lpc_mmtx_s6 ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "    mmtx_csysreq_main ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "      mmtx_csysreq_m0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "      mmtx_csysreq_m1 ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "      mmtx_csysreq_m2 ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "      mmtx_csysreq_m3 ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "      mmtx_csysreq_m4 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "      mmtx_csysreq_m5 ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "      mmtx_csysreq_m6 ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "      mmtx_csysreq_s0 ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "      mmtx_csysreq_s1 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 11. "      mmtx_csysreq_s2 ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "      mmtx_csysreq_s3 ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "      mmtx_csysreq_s4 ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "      mmtx_csysreq_s5 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "      mmtx_csysreq_s6 ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "      mmtx_lp_stat_m0 ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "      mmtx_lp_stat_m1 ," "0   ,%d..."
    BITFLD.LONG 0x00 4. "      mmtx_lp_stat_m2 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. "      mmtx_lp_stat_m3 ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "      mmtx_lp_stat_m4 ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "      mmtx_lp_stat_m5 ," "0   ,%d..."
    BITFLD.LONG 0x00 0. "      mmtx_lp_stat_m6 ," "0   ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_lpc @ mmtx_lpc_dbg_out_0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 7(0x7)" 
    VARX 0x00 %l SWD.read(0x00000700)
    TEXTLINE ""
    LINE.LONG 0x00 " mmtx_lpc_dbg_out_0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "    mmtx_lp_stat_main ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "      mmtx_lp_stat_s0 ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "      mmtx_lp_stat_s1 ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      mmtx_lp_stat_s2 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "      mmtx_lp_stat_s3 ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "      mmtx_lp_stat_s4 ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "      mmtx_lp_stat_s5 ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "      mmtx_lp_stat_s6 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 23. " mmtx_m0_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 22. "    mmtx_m0_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "    mmtx_m1_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "    mmtx_m2_force_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. " mmtx_m3_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "    mmtx_m3_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "    mmtx_m4_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "    mmtx_m5_force_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "    mmtx_m6_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "  mmtx_main_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 13. " mmtx_s0_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "    mmtx_s0_force_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 11. " mmtx_s1_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "    mmtx_s1_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 9. " mmtx_s2_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "    mmtx_s2_force_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. " mmtx_s3_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "    mmtx_s3_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " mmtx_s4_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 4. "    mmtx_s4_force_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. " mmtx_s5_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "    mmtx_s5_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 1. " mmtx_s6_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 0. "    mmtx_s6_force_ack ," "0   ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_lp_ctrl @ lp_ctrl_dbg_out_1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 8(0x8)" 
    VARX 0x00 %l SWD.read(0x00000800)
    TEXTLINE ""
    LINE.LONG 0x00 " lp_ctrl_dbg_out_1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 25.--31. "                   reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 24. "     cgm_busy_clk_apcpu_axi ," "0    ,%d..."
    BITFLD.LONG 0x00 23. "         ap_srst_frc_lp_ack ," "0    ,%d..."
    BITFLD.LONG 0x00 22. "              mmtx_pub_dslp ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 21. "              mmtx_sleep_m0 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "              mmtx_sleep_m1 ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "              mmtx_sleep_m2 ," "0    ,%d..."
    BITFLD.LONG 0x00 18. "              mmtx_sleep_m3 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 17. "              mmtx_sleep_m4 ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "              mmtx_sleep_m5 ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "              mmtx_sleep_m6 ," "0    ,%d..."
    BITFLD.LONG 0x00 14. "     ap_sys_light_sleep_req ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 13. "      ap_sys_deep_sleep_req ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "      ap_sys_doze_sleep_req ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "   ap_sys_mtx_pub_deep_stop ," "0    ,%d..."
    BITFLD.LONG 0x00 10. "            ap_sys_apb_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 9. "                   reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "                   reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 7. "                  mmtx_lslp ," "0    ,%d..."
    BITFLD.LONG 0x00 6. "        ap_sys_apb_bus_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 5. "         cgm_ap_peri_apb_en ," "0    ,%d..."
    BITFLD.LONG 0x00 4. " ap_peri_apb_frequency_down ," "0    ,%d..."
    BITFLD.LONG 0x00 3. "       clk_apcpu_axi_in0_en ," "0    ,%d..."
    BITFLD.LONG 0x00 2. "       clk_apcpu_axi_in1_en ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 1. "       clk_apcpu_axi_in2_en ," "0    ,%d..."
    BITFLD.LONG 0x00 0. "       clk_apcpu_axi_in3_en ," "0    ,%d..."
    SGROUP "u_sys_ap.u_ap_top.u_lp_ctrl @ lp_ctrl_dbg_out_0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 9(0x9)" 
    VARX 0x00 %l SWD.read(0x00000900)
    TEXTLINE ""
    LINE.LONG 0x00 " lp_ctrl_dbg_out_0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "                         reserved ," "0x0 ,%x..."
    BITFLD.LONG 0x00 29. "      cgm_peri_apb_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "         cgm_uart0_en_after_force ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "          cgm_i2c0_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "          cgm_i2c1_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "          cgm_i2c2_en_after_force ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 24. "          cgm_i2c3_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "          cgm_i2c4_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 22. "          cgm_spi0_en_after_force ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 21. "          cgm_spi1_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "          cgm_spi2_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "      cgm_emmc_32k_en_after_force ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "  cgm_sdio_mst_32k_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "       cgm_sim_32k_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "           cgm_sim_en_after_force ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "          cgm_pwm0_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "          cgm_pwm1_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "          cgm_pwm2_en_after_force ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. "          cgm_pwm3_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "      cgm_usb0_ref_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "     cgm_nandc_ecc_en_after_force ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 9. "     cgm_nandc_26m_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 8. " cgm_sdio_slv_frun_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "      cgm_usb1_ref_en_after_force ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 6. "      cgm_pcie_aux_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "          cgm_emmc_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 4. "         cgm_nandc_en_after_force ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. "      cgm_sdio_mst_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "      cgm_sdio_slv_en_after_force ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "  cgm_usb0_suspend_en_after_force ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "  cgm_usb1_suspend_en_after_force ," "0   ,%d..."
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_lpc @ imtx_lpc_dbg_out_3"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 10(0xa)" 
    VARX 0x00 %l SWD.read(0x00000A00)
    TEXTLINE ""
    LINE.LONG 0x00 " imtx_lpc_dbg_out_3 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 7.--31. "             reserved ," "0x0       ,%x..."
    BITFLD.LONG 0x00 6. " cgm_busy_lpc_imtx_m0 ," "0         ,%d..."
    BITFLD.LONG 0x00 5. " cgm_busy_lpc_imtx_m1 ," "0         ,%d..."
    BITFLD.LONG 0x00 4. " cgm_busy_lpc_imtx_m2 ," "0         ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. " cgm_busy_lpc_imtx_m3 ," "0         ,%d..."
    BITFLD.LONG 0x00 2. " cgm_busy_lpc_imtx_m4 ," "0         ,%d..."
    BITFLD.LONG 0x00 1. " cgm_busy_lpc_imtx_m5 ," "0         ,%d..."
    BITFLD.LONG 0x00 0. " cgm_busy_lpc_imtx_m6 ," "0         ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_lpc @ imtx_lpc_dbg_out_2"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 11(0xb)" 
    VARX 0x00 %l SWD.read(0x00000B00)
    TEXTLINE ""
    LINE.LONG 0x00 " imtx_lpc_dbg_out_2 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "  cgm_busy_lpc_imtx_m7 ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "  cgm_busy_lpc_imtx_m8 ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "  cgm_busy_lpc_imtx_m9 ," "0   ,%d..."
    BITFLD.LONG 0x00 28. " cgm_busy_lpc_imtx_m10 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "  cgm_busy_lpc_imtx_s0 ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "  cgm_busy_lpc_imtx_s1 ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "  cgm_busy_lpc_imtx_s2 ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "  cgm_busy_lpc_imtx_s3 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 23. "  cgm_busy_lpc_imtx_s4 ," "0   ,%d..."
    BITFLD.LONG 0x00 22. "  cgm_busy_lpc_imtx_s5 ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "  cgm_busy_lpc_imtx_s6 ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "  cgm_busy_lpc_imtx_s7 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "  cgm_busy_lpc_imtx_s8 ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "  cgm_busy_lpc_imtx_s9 ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "     cgm_busy_lpc_main ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "     imtx_csysreq_main ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "       imtx_csysreq_m0 ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "       imtx_csysreq_m1 ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "       imtx_csysreq_m2 ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "       imtx_csysreq_m3 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 11. "       imtx_csysreq_m4 ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "       imtx_csysreq_m5 ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "       imtx_csysreq_m6 ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "       imtx_csysreq_m7 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "       imtx_csysreq_m8 ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "       imtx_csysreq_m9 ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "      imtx_csysreq_m10 ," "0   ,%d..."
    BITFLD.LONG 0x00 4. "       imtx_csysreq_s0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. "       imtx_csysreq_s1 ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "       imtx_csysreq_s2 ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "       imtx_csysreq_s3 ," "0   ,%d..."
    BITFLD.LONG 0x00 0. "       imtx_csysreq_s4 ," "0   ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_lpc @ imtx_lpc_dbg_out_1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 12(0xc)" 
    VARX 0x00 %l SWD.read(0x00000C00)
    TEXTLINE ""
    LINE.LONG 0x00 " imtx_lpc_dbg_out_1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "      imtx_csysreq_s5 ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "      imtx_csysreq_s6 ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "      imtx_csysreq_s7 ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      imtx_csysreq_s8 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "      imtx_csysreq_s9 ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "      imtx_lp_stat_m0 ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "      imtx_lp_stat_m1 ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "      imtx_lp_stat_m2 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 23. "      imtx_lp_stat_m3 ," "0   ,%d..."
    BITFLD.LONG 0x00 22. "      imtx_lp_stat_m4 ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "      imtx_lp_stat_m5 ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "      imtx_lp_stat_m6 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "      imtx_lp_stat_m7 ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "      imtx_lp_stat_m8 ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "      imtx_lp_stat_m9 ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "     imtx_lp_stat_m10 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "    imtx_lp_stat_main ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "      imtx_lp_stat_s0 ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "      imtx_lp_stat_s1 ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "      imtx_lp_stat_s2 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 11. "      imtx_lp_stat_s3 ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "      imtx_lp_stat_s4 ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "      imtx_lp_stat_s5 ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "      imtx_lp_stat_s6 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "      imtx_lp_stat_s7 ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "      imtx_lp_stat_s8 ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "      imtx_lp_stat_s9 ," "0   ,%d..."
    BITFLD.LONG 0x00 4. "    imtx_m0_force_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. "    imtx_m1_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " imtx_m2_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "    imtx_m2_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 0. " imtx_m3_early_wakeup ," "0   ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_lpc @ imtx_lpc_dbg_out_0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 13(0xd)" 
    VARX 0x00 %l SWD.read(0x00000D00)
    TEXTLINE ""
    LINE.LONG 0x00 " imtx_lpc_dbg_out_0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "    imtx_m3_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 30. " imtx_m4_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "    imtx_m4_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "    imtx_m5_force_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "    imtx_m6_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "    imtx_m7_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "    imtx_m8_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 24. " imtx_m9_early_wakeup ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 23. "    imtx_m9_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 22. "   imtx_m10_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "  imtx_main_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 20. " imtx_s0_early_wakeup ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "    imtx_s0_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 18. " imtx_s1_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "    imtx_s1_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 16. " imtx_s2_early_wakeup ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "    imtx_s2_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 14. " imtx_s3_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "    imtx_s3_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " imtx_s4_early_wakeup ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 11. "    imtx_s4_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 10. " imtx_s5_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "     imtx_s5_lp_force ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "    imtx_s5_force_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. " imtx_s6_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "    imtx_s6_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " imtx_s7_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 4. "    imtx_s7_force_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. " imtx_s8_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "    imtx_s8_force_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 1. " imtx_s9_early_wakeup ," "0   ,%d..."
    BITFLD.LONG 0x00 0. "    imtx_s9_force_ack ," "0   ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_lp_ctrl @ ipa_lp_ctrl_dbg_out_1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 14(0xe)" 
    VARX 0x00 %l SWD.read(0x00000E00)
    TEXTLINE ""
    LINE.LONG 0x00 " ipa_lp_ctrl_dbg_out_1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 3.--31. "         reserved ," "0x0        ,%x..."
    BITFLD.LONG 0x00 2. "        mmtx_lslp ," "0          ,%d..."
    BITFLD.LONG 0x00 1. " cp0_sys_sw_sleep ," "0          ,%d..."
    BITFLD.LONG 0x00 0. " cp1_sys_sw_sleep ," "0          ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_lp_ctrl @ ipa_lp_ctrl_dbg_out_0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 15(0xf)" 
    VARX 0x00 %l SWD.read(0x00000F00)
    TEXTLINE ""
    LINE.LONG 0x00 " ipa_lp_ctrl_dbg_out_0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "             cp0_sys_stop ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "             cp1_sys_stop ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "           ap_apb_frc_slp ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "       ap_srst_frc_lp_req ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        ap_ddr_pwr_hs_req ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "          ap_ipa_apb_idle ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "            imtx_pub_dslp ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "                imtx_dslp ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 23. "                imtx_doze ," "0   ,%d..."
    BITFLD.LONG 0x00 22. "                imtx_lslp ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "                 reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "     cgm_busy_clk_cp0_axi ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "     cgm_busy_clk_cp1_axi ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "      imtx_clk_axi_in1_en ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "      imtx_clk_axi_in3_en ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "      imtx_clk_axi_in4_en ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "      imtx_clk_axi_in5_en ," "0   ,%d..."
    BITFLD.LONG 0x00 14. " imtx_clk_axi_lslp_in1_en ," "0   ,%d..."
    BITFLD.LONG 0x00 13. " imtx_clk_axi_lslp_in3_en ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " imtx_clk_axi_lslp_in4_en ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 11. " imtx_clk_axi_lslp_in5_en ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "            imtx_sleep_m0 ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "            imtx_sleep_m1 ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "            imtx_sleep_m2 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "            imtx_sleep_m3 ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "            imtx_sleep_m4 ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "            imtx_sleep_m5 ," "0   ,%d..."
    BITFLD.LONG 0x00 4. "            imtx_sleep_m6 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. "            imtx_sleep_m7 ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "            imtx_sleep_m8 ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "            imtx_sleep_m9 ," "0   ,%d..."
    BITFLD.LONG 0x00 0. "           imtx_sleep_m10 ," "0   ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top @ ipa_sys_dbg_out_0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 16(0x10)" 
    VARX 0x00 %l SWD.read(0x00001000)
    TEXTLINE ""
    LINE.LONG 0x00 " ipa_sys_dbg_out_0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 28.--31. "                     reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 27. "   sdio_slv_pclk_auto_gate_eb ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "  pcie_snps_pclk_auto_gate_eb ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 25. "    pcie_xz_pclk_auto_gate_eb ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "    usb_pam_pclk_auto_gate_eb ," "0    ,%d..."
    BITFLD.LONG 0x00 23. "   pam_wifi_pclk_auto_gate_eb ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "                     pcie_sel ," "0    ,%d..."
    BITFLD.LONG 0x00 21. "                   usb_pam_eb ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "                       ipa_eb ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "                  pcie_aux_eb ," "0    ,%d..."
    BITFLD.LONG 0x00 18. "                     spcie_eb ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "             sdio_slv_frun_eb ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "                  sdio_slv_eb ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "                  usb1_ref_eb ," "0    ,%d..."
    BITFLD.LONG 0x00 14. "              usb1_suspend_eb ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 13. "                      usb1_eb ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "  cgm_clk_ap_axi_auto_gate_en ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "                  pam_wifi_eb ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "         cgm_busy_clk_cp1_axi ," "0    ,%d..."
    BITFLD.LONG 0x00 9. " cgm_clk_cp0_axi_auto_gate_en ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "             int_req_pcie_sys ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--7. "         bus_busy_busmon[7:0] ," "0x0  ,%x..."
    SGROUP "u_sys_ap.u_ap_top.u_clk_top @ ap_clk_dbg_bus_0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 17(0x11)" 
    VARX 0x00 %l SWD.read(0x00001100)
    TEXTLINE ""
    LINE.LONG 0x00 " ap_clk_dbg_bus_0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 2.--31. "              reserved ," "0x0        ,%x..."
    BITFLD.LONG 0x00 0.--1. " cgm_peri_apb_sel[1:0] ," "0x0        ,%x..."
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_s6 @ nic400_ap_main_mtx_dbg_bus[31:0]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 18(0x12)" 
    VARX 0x00 %l SWD.read(0x00001200)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[31:0] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_s6 @ nic400_ap_main_mtx_dbg_bus[63:32]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 19(0x13)" 
    VARX 0x00 %l SWD.read(0x00001300)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[63:32] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_s5 @ nic400_ap_main_mtx_dbg_bus[95:64]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 20(0x14)" 
    VARX 0x00 %l SWD.read(0x00001400)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[95:64] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_s5 @ nic400_ap_main_mtx_dbg_bus[127:96]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 21(0x15)" 
    VARX 0x00 %l SWD.read(0x00001500)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[127:96] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_s4 @ nic400_ap_main_mtx_dbg_bus[159:128]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 22(0x16)" 
    VARX 0x00 %l SWD.read(0x00001600)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[159:128] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_s4 @ nic400_ap_main_mtx_dbg_bus[191:160]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 23(0x17)" 
    VARX 0x00 %l SWD.read(0x00001700)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[191:160] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_s3 @ nic400_ap_main_mtx_dbg_bus[223:192]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 24(0x18)" 
    VARX 0x00 %l SWD.read(0x00001800)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[223:192] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 20.--31. "    reserved ," "0x0   ,%x..."
    BITFLD.LONG 0x00 19. "        psel ," "0     ,%d..."
    BITFLD.LONG 0x00 18. "     penable ," "0     ,%d..."
    BITFLD.LONG 0x00 17. "      pwrite ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "      pready ," "0     ,%d..."
    BITFLD.LONG 0x00 8.--15. " wr_cnt[7:0] ," "0     ,%d..."
    BITFLD.LONG 0x00 0.--7. " rd_cnt[7:0] ," "0     ,%d..."
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_s2 @ nic400_ap_main_mtx_dbg_bus[255:224]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 25(0x19)" 
    VARX 0x00 %l SWD.read(0x00001900)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[255:224] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_s2 @ nic400_ap_main_mtx_dbg_bus[287:256]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 26(0x1a)" 
    VARX 0x00 %l SWD.read(0x00001A00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[287:256] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_s1 @ nic400_ap_main_mtx_dbg_bus[319:288]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 27(0x1b)" 
    VARX 0x00 %l SWD.read(0x00001B00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[319:288] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--31. "    reserved ," "0x0   ,%x..."
    BITFLD.LONG 0x00 21. "    bus_idle ," "0     ,%d..."
    BITFLD.LONG 0x00 20. "        hsel ," "0     ,%d..."
    BITFLD.LONG 0x00 18.--19. " htrans[1:0] ," "0x0   ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 17. "      hwrite ," "0     ,%d..."
    BITFLD.LONG 0x00 16. "      hready ," "0     ,%d..."
    BITFLD.LONG 0x00 8.--15. " rd_cnt[7:0] ," "0     ,%d..."
    BITFLD.LONG 0x00 0.--7. " wr_cnt[7:0] ," "0     ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_s0 @ nic400_ap_main_mtx_dbg_bus[351:320]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 28(0x1c)" 
    VARX 0x00 %l SWD.read(0x00001C00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[351:320] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 20.--31. "    reserved ," "0x0   ,%x..."
    BITFLD.LONG 0x00 19. "        psel ," "0     ,%d..."
    BITFLD.LONG 0x00 18. "     penable ," "0     ,%d..."
    BITFLD.LONG 0x00 17. "      pwrite ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "      pready ," "0     ,%d..."
    BITFLD.LONG 0x00 8.--15. " wr_cnt[7:0] ," "0     ,%d..."
    BITFLD.LONG 0x00 0.--7. " rd_cnt[7:0] ," "0     ,%d..."
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_m6 @ nic400_ap_main_mtx_dbg_bus[383:352]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 29(0x1d)" 
    VARX 0x00 %l SWD.read(0x00001D00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[383:352] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_m6 @ nic400_ap_main_mtx_dbg_bus[415:384]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 30(0x1e)" 
    VARX 0x00 %l SWD.read(0x00001E00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[415:384] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_m5 @ nic400_ap_main_mtx_dbg_bus[447:416]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 31(0x1f)" 
    VARX 0x00 %l SWD.read(0x00001F00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[447:416] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_m5 @ nic400_ap_main_mtx_dbg_bus[479:448]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 32(0x20)" 
    VARX 0x00 %l SWD.read(0x00002000)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[479:448] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_m4 @ nic400_ap_main_mtx_dbg_bus[511:480]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 33(0x21)" 
    VARX 0x00 %l SWD.read(0x00002100)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[511:480] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_m4 @ nic400_ap_main_mtx_dbg_bus[543:512]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 34(0x22)" 
    VARX 0x00 %l SWD.read(0x00002200)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[543:512] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_m3 @ nic400_ap_main_mtx_dbg_bus[575:544]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 35(0x23)" 
    VARX 0x00 %l SWD.read(0x00002300)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[575:544] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_m3 @ nic400_ap_main_mtx_dbg_bus[607:576]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 36(0x24)" 
    VARX 0x00 %l SWD.read(0x00002400)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[607:576] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_m2 @ nic400_ap_main_mtx_dbg_bus[639:608]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 37(0x25)" 
    VARX 0x00 %l SWD.read(0x00002500)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[639:608] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_m2 @ nic400_ap_main_mtx_dbg_bus[671:640]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 38(0x26)" 
    VARX 0x00 %l SWD.read(0x00002600)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[671:640] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_m1 @ nic400_ap_main_mtx_dbg_bus[703:672]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 39(0x27)" 
    VARX 0x00 %l SWD.read(0x00002700)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[703:672] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_m1 @ nic400_ap_main_mtx_dbg_bus[735:704]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 40(0x28)" 
    VARX 0x00 %l SWD.read(0x00002800)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[735:704] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_m0 @ nic400_ap_main_mtx_dbg_bus[767:736]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 41(0x29)" 
    VARX 0x00 %l SWD.read(0x00002900)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[767:736] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap.u_axi_trans_mon_m0 @ nic400_ap_main_mtx_dbg_bus[799:768]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 42(0x2a)" 
    VARX 0x00 %l SWD.read(0x00002A00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[799:768] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap @ nic400_ap_main_mtx_dbg_bus[831:800]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 43(0x2b)" 
    VARX 0x00 %l SWD.read(0x00002B00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[831:800] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "        reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 30. " ccative_cd_main ," "0   ,%d..."
    BITFLD.LONG 0x00 29. " csysack_cd_main ," "0   ,%d..."
    BITFLD.LONG 0x00 28. " csysreq_cd_main ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "   ccative_cd_s0 ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "   csysack_cd_s0 ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "   csysreq_cd_s0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 23. "        reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 22. "   ccative_cd_s1 ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "   csysack_cd_s1 ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "   csysreq_cd_s1 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "        reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "   ccative_cd_s2 ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "   csysack_cd_s2 ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "   csysreq_cd_s2 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "        reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "   ccative_cd_s3 ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "   csysack_cd_s3 ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "   csysreq_cd_s3 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 11. "        reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "   ccative_cd_s4 ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "   csysack_cd_s4 ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "   csysreq_cd_s4 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "        reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "   ccative_cd_s5 ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "   csysack_cd_s5 ," "0   ,%d..."
    BITFLD.LONG 0x00 4. "   csysreq_cd_s5 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. "        reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "   ccative_cd_s6 ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "   csysack_cd_s6 ," "0   ,%d..."
    BITFLD.LONG 0x00 0. "   csysreq_cd_s6 ," "0   ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_mmtx_wrap @ nic400_ap_main_mtx_dbg_bus[859:832]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 44(0x2c)" 
    VARX 0x00 %l SWD.read(0x00002C00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[859:832] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 27.--31. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 26. " ccative_cd_m0 ," "0    ,%d..."
    BITFLD.LONG 0x00 25. " csysack_cd_m0 ," "0    ,%d..."
    BITFLD.LONG 0x00 24. " csysreq_cd_m0 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 23. "      reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 22. " ccative_cd_m1 ," "0    ,%d..."
    BITFLD.LONG 0x00 21. " csysack_cd_m1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. " csysreq_cd_m1 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "      reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 18. " ccative_cd_m2 ," "0    ,%d..."
    BITFLD.LONG 0x00 17. " csysack_cd_m2 ," "0    ,%d..."
    BITFLD.LONG 0x00 16. " csysreq_cd_m2 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "      reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 14. " ccative_cd_m3 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. " csysack_cd_m3 ," "0    ,%d..."
    BITFLD.LONG 0x00 12. " csysreq_cd_m3 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 11. "      reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 10. " ccative_cd_m4 ," "0    ,%d..."
    BITFLD.LONG 0x00 9. " csysack_cd_m4 ," "0    ,%d..."
    BITFLD.LONG 0x00 8. " csysreq_cd_m4 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "      reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 6. " ccative_cd_m5 ," "0    ,%d..."
    BITFLD.LONG 0x00 5. " csysack_cd_m5 ," "0    ,%d..."
    BITFLD.LONG 0x00 4. " csysreq_cd_m5 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. "      reserved ," "0    ,%d..."
    BITFLD.LONG 0x00 2. " ccative_cd_m6 ," "0    ,%d..."
    BITFLD.LONG 0x00 1. " csysack_cd_m6 ," "0    ,%d..."
    BITFLD.LONG 0x00 0. " csysreq_cd_m6 ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_s9 @ nic400_ap_ipa_mtx_dbg_bus[31:0]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 45(0x2d)" 
    VARX 0x00 %l SWD.read(0x00002D00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[31:0] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_s9 @ nic400_ap_ipa_mtx_dbg_bus[63:32]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 46(0x2e)" 
    VARX 0x00 %l SWD.read(0x00002E00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[63:32] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_s8 @ nic400_ap_ipa_mtx_dbg_bus[95:64]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 47(0x2f)" 
    VARX 0x00 %l SWD.read(0x00002F00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[95:64] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 20.--31. "    reserved ," "0x0   ,%x..."
    BITFLD.LONG 0x00 19. "        psel ," "0     ,%d..."
    BITFLD.LONG 0x00 18. "     penable ," "0     ,%d..."
    BITFLD.LONG 0x00 17. "      pwrite ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "      pready ," "0     ,%d..."
    BITFLD.LONG 0x00 8.--15. " wr_cnt[7:0] ," "0     ,%d..."
    BITFLD.LONG 0x00 0.--7. " rd_cnt[7:0] ," "0     ,%d..."
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_s7 @ nic400_ap_ipa_mtx_dbg_bus[127:96]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 48(0x30)" 
    VARX 0x00 %l SWD.read(0x00003000)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[127:96] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 20.--31. "    reserved ," "0x0   ,%x..."
    BITFLD.LONG 0x00 19. "        psel ," "0     ,%d..."
    BITFLD.LONG 0x00 18. "     penable ," "0     ,%d..."
    BITFLD.LONG 0x00 17. "      pwrite ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "      pready ," "0     ,%d..."
    BITFLD.LONG 0x00 8.--15. " wr_cnt[7:0] ," "0     ,%d..."
    BITFLD.LONG 0x00 0.--7. " rd_cnt[7:0] ," "0     ,%d..."
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_s6 @ nic400_ap_ipa_mtx_dbg_bus[159:128]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 49(0x31)" 
    VARX 0x00 %l SWD.read(0x00003100)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[159:128] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_s6 @ nic400_ap_ipa_mtx_dbg_bus[191:160]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 50(0x32)" 
    VARX 0x00 %l SWD.read(0x00003200)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[191:160] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_s5 @ nic400_ap_ipa_mtx_dbg_bus[223:192]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 51(0x33)" 
    VARX 0x00 %l SWD.read(0x00003300)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[223:192] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_s5 @ nic400_ap_ipa_mtx_dbg_bus[255:224]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 52(0x34)" 
    VARX 0x00 %l SWD.read(0x00003400)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[255:224] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_s4 @ nic400_ap_ipa_mtx_dbg_bus[287:256]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 53(0x35)" 
    VARX 0x00 %l SWD.read(0x00003500)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[287:256] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_s4 @ nic400_ap_ipa_mtx_dbg_bus[319:288]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 54(0x36)" 
    VARX 0x00 %l SWD.read(0x00003600)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[319:288] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_s3 @ nic400_ap_ipa_mtx_dbg_bus[351:320]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 55(0x37)" 
    VARX 0x00 %l SWD.read(0x00003700)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[351:320] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_s3 @ nic400_ap_ipa_mtx_dbg_bus[383:352]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 56(0x38)" 
    VARX 0x00 %l SWD.read(0x00003800)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[383:352] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_s2 @ nic400_ap_ipa_mtx_dbg_bus[415:384]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 57(0x39)" 
    VARX 0x00 %l SWD.read(0x00003900)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[415:384] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_s2 @ nic400_ap_ipa_mtx_dbg_bus[447:416]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 58(0x3a)" 
    VARX 0x00 %l SWD.read(0x00003A00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[447:416] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_s1 @ nic400_ap_main_mtx_dbg_bus[479:448]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 59(0x3b)" 
    VARX 0x00 %l SWD.read(0x00003B00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[479:448] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--31. "    reserved ," "0x0   ,%x..."
    BITFLD.LONG 0x00 21. "    bus_idle ," "0     ,%d..."
    BITFLD.LONG 0x00 20. "        hsel ," "0     ,%d..."
    BITFLD.LONG 0x00 18.--19. " htrans[1:0] ," "0x0   ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 17. "      hwrite ," "0     ,%d..."
    BITFLD.LONG 0x00 16. "      hready ," "0     ,%d..."
    BITFLD.LONG 0x00 8.--15. " rd_cnt[7:0] ," "0     ,%d..."
    BITFLD.LONG 0x00 0.--7. " wr_cnt[7:0] ," "0     ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_s0 @ nic400_ap_ipa_mtx_dbg_bus[511:480]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 60(0x3c)" 
    VARX 0x00 %l SWD.read(0x00003C00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[511:480] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 20.--31. "    reserved ," "0x0   ,%x..."
    BITFLD.LONG 0x00 19. "        psel ," "0     ,%d..."
    BITFLD.LONG 0x00 18. "     penable ," "0     ,%d..."
    BITFLD.LONG 0x00 17. "      pwrite ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "      pready ," "0     ,%d..."
    BITFLD.LONG 0x00 8.--15. " wr_cnt[7:0] ," "0     ,%d..."
    BITFLD.LONG 0x00 0.--7. " rd_cnt[7:0] ," "0     ,%d..."
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m9 @ nic400_ap_ipa_mtx_dbg_bus[543:512]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 61(0x3d)" 
    VARX 0x00 %l SWD.read(0x00003D00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[543:512] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m9 @ nic400_ap_ipa_mtx_dbg_bus[575:544]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 62(0x3e)" 
    VARX 0x00 %l SWD.read(0x00003E00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[575:544] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m8 @ nic400_ap_ipa_mtx_dbg_bus[607:576]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 63(0x3f)" 
    VARX 0x00 %l SWD.read(0x00003F00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[607:576] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m8 @ nic400_ap_ipa_mtx_dbg_bus[639:608]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 64(0x40)" 
    VARX 0x00 %l SWD.read(0x00004000)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[639:608] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m7 @ nic400_ap_ipa_mtx_dbg_bus[671:640]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 65(0x41)" 
    VARX 0x00 %l SWD.read(0x00004100)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[671:640] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m7 @ nic400_ap_ipa_mtx_dbg_bus[703:672]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 66(0x42)" 
    VARX 0x00 %l SWD.read(0x00004200)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[703:672] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m6 @ nic400_ap_ipa_mtx_dbg_bus[735:704]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 67(0x43)" 
    VARX 0x00 %l SWD.read(0x00004300)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[735:704] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m6 @ nic400_ap_ipa_mtx_dbg_bus[767:736]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 68(0x44)" 
    VARX 0x00 %l SWD.read(0x00004400)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[767:736] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m5 @ nic400_ap_ipa_mtx_dbg_bus[799:768]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 69(0x45)" 
    VARX 0x00 %l SWD.read(0x00004500)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[799:768] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m5 @ nic400_ap_ipa_mtx_dbg_bus[831:800]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 70(0x46)" 
    VARX 0x00 %l SWD.read(0x00004600)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[831:800] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m4 @ nic400_ap_ipa_mtx_dbg_bus[863:832]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 71(0x47)" 
    VARX 0x00 %l SWD.read(0x00004700)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[863:832] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m4 @ nic400_ap_ipa_mtx_dbg_bus[895:864]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 72(0x48)" 
    VARX 0x00 %l SWD.read(0x00004800)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[895:864] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m3 @ nic400_ap_ipa_mtx_dbg_bus[927:896]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 73(0x49)" 
    VARX 0x00 %l SWD.read(0x00004900)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[927:896] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m3 @ nic400_ap_ipa_mtx_dbg_bus[959:928]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 74(0x4a)" 
    VARX 0x00 %l SWD.read(0x00004A00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[959:928] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m2 @ nic400_ap_ipa_mtx_dbg_bus[991:960]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 75(0x4b)" 
    VARX 0x00 %l SWD.read(0x00004B00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[991:960] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m2 @ nic400_ap_ipa_mtx_dbg_bus[1023:992]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 76(0x4c)" 
    VARX 0x00 %l SWD.read(0x00004C00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[1023:992] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m10 @ nic400_ap_ipa_mtx_dbg_bus[1055:1024]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 77(0x4d)" 
    VARX 0x00 %l SWD.read(0x00004D00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[1055:1024] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m10 @ nic400_ap_ipa_mtx_dbg_bus[1087:1056]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 78(0x4e)" 
    VARX 0x00 %l SWD.read(0x00004E00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[1087:1056] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m1 @ nic400_ap_ipa_mtx_dbg_bus[1119:1088]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 79(0x4f)" 
    VARX 0x00 %l SWD.read(0x00004F00)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[1119:1088] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m1 @ nic400_ap_ipa_mtx_dbg_bus[1151:1120]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 80(0x50)" 
    VARX 0x00 %l SWD.read(0x00005000)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_ipa_mtx_dbg_bus[1151:1120] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m0 @ nic400_ap_main_mtx_dbg_bus[1183:1152]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 81(0x51)" 
    VARX 0x00 %l SWD.read(0x00005100)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[1183:1152] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. " ar_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--23. "  b_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--15. "  w_cnt[7:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. " aw_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap.u_axi_trans_mon_m0 @ nic400_ap_main_mtx_dbg_bus[1215:1184]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 82(0x52)" 
    VARX 0x00 %l SWD.read(0x00005200)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[1215:1184] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. " ar_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. "  ar_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   ar_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "         rlast ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        rvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        rready ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       arvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       arready ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22.--23. "      reserved ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21. "  w_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "   w_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "    w_overflow ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "         wlast ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "        wvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "        wready ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "    trans_idle ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " aw_underflow1 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "  aw_underflow ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "   aw_overflow ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "        bvalid ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "        bready ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       awvalid ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "       awready ," "0    ,%d..."
    BITFLD.LONG 0x00 0.--7. "    r_cnt[7:0] ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap @ nic400_ap_main_mtx_dbg_bus[1247:1216]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 83(0x53)" 
    VARX 0x00 %l SWD.read(0x00005300)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[1247:1216] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "      reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 30. " ccative_cd_s2 ," "0   ,%d..."
    BITFLD.LONG 0x00 29. " csysack_cd_s2 ," "0   ,%d..."
    BITFLD.LONG 0x00 28. " csysreq_cd_s2 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "      reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 26. " ccative_cd_s3 ," "0   ,%d..."
    BITFLD.LONG 0x00 25. " csysack_cd_s3 ," "0   ,%d..."
    BITFLD.LONG 0x00 24. " csysreq_cd_s3 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 23. "      reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 22. " ccative_cd_s4 ," "0   ,%d..."
    BITFLD.LONG 0x00 21. " csysack_cd_s4 ," "0   ,%d..."
    BITFLD.LONG 0x00 20. " csysreq_cd_s4 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "      reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 18. " ccative_cd_s5 ," "0   ,%d..."
    BITFLD.LONG 0x00 17. " csysack_cd_s5 ," "0   ,%d..."
    BITFLD.LONG 0x00 16. " csysreq_cd_s5 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "      reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 14. " ccative_cd_s6 ," "0   ,%d..."
    BITFLD.LONG 0x00 13. " csysack_cd_s6 ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " csysreq_cd_s6 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 11. "      reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 10. " ccative_cd_s7 ," "0   ,%d..."
    BITFLD.LONG 0x00 9. " csysack_cd_s7 ," "0   ,%d..."
    BITFLD.LONG 0x00 8. " csysreq_cd_s7 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "      reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 6. " ccative_cd_s8 ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " csysack_cd_s8 ," "0   ,%d..."
    BITFLD.LONG 0x00 4. " csysreq_cd_s8 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. "      reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " ccative_cd_s9 ," "0   ,%d..."
    BITFLD.LONG 0x00 1. " csysack_cd_s9 ," "0   ,%d..."
    BITFLD.LONG 0x00 0. " csysreq_cd_s9 ," "0   ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap @ nic400_ap_main_mtx_dbg_bus[1279:1248]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 84(0x54)" 
    VARX 0x00 %l SWD.read(0x00005400)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[1279:1248] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "        reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "   ccative_cd_m5 ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "   csysack_cd_m5 ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "   csysreq_cd_m5 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27. "        reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "   ccative_cd_m6 ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "   csysack_cd_m6 ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "   csysreq_cd_m6 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 23. "        reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 22. "   ccative_cd_m7 ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "   csysack_cd_m7 ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "   csysreq_cd_m7 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "        reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "   ccative_cd_m8 ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "   csysack_cd_m8 ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "   csysreq_cd_m8 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "        reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "   ccative_cd_m9 ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "   csysack_cd_m9 ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "   csysreq_cd_m9 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 11. "        reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 10. " ccative_cd_main ," "0   ,%d..."
    BITFLD.LONG 0x00 9. " csysack_cd_main ," "0   ,%d..."
    BITFLD.LONG 0x00 8. " csysreq_cd_main ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 7. "        reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "   ccative_cd_s0 ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "   csysack_cd_s0 ," "0   ,%d..."
    BITFLD.LONG 0x00 4. "   csysreq_cd_s0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. "        reserved ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "   ccative_cd_s1 ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "   csysack_cd_s1 ," "0   ,%d..."
    BITFLD.LONG 0x00 0. "   csysreq_cd_s1 ," "0   ,%d..."
    TEXTLINE ""
    SGROUP "u_sys_ap.u_ap_top.u_ipa_sys_top.u_imtx_wrap @ nic400_ap_main_mtx_dbg_bus[1303:1311]"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 85(0x55)" 
    VARX 0x00 %l SWD.read(0x00005500)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_main_mtx_dbg_bus[1303:1311] "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "  ccative_cd_m0 ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "  csysack_cd_m0 ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "  csysreq_cd_m0 ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "       reserved ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "  ccative_cd_m1 ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  csysack_cd_m1 ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "  csysreq_cd_m1 ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "       reserved ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " ccative_cd_m10 ," "0   ,%d..."
    BITFLD.LONG 0x00 13. " csysack_cd_m10 ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " csysreq_cd_m10 ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "       reserved ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "  ccative_cd_m2 ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "  csysack_cd_m2 ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "  csysreq_cd_m2 ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "       reserved ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 6. "  ccative_cd_m3 ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "  csysack_cd_m3 ," "0   ,%d..."
    BITFLD.LONG 0x00 4. "  csysreq_cd_m3 ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "       reserved ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 2. "  ccative_cd_m4 ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "  csysack_cd_m4 ," "0   ,%d..."
    BITFLD.LONG 0x00 0. "  csysreq_cd_m4 ," "0   ,%d..."
TREE.END
