;This file is generated by Trace32PerBuilder Version:0.5.3.
;  Please access external network Trace32 Per Builder Homepage for documents
;and source code.
;   http://wikiserver.spreadtrum.com/Projects/SoftwareSystem/wiki/BbDrvTools/Trace32PerBuilder

config 16. 8.
width 44.
BASE EAPB:0x0
;###################Tree###################
TREE "AP"
    SGROUP "AP @ chain_status_slp RO"
;-------------------------------------------------
    VARX 0x04 %l DBUS.read(0x00010100)
    TEXTLINE ""
    LINE.LONG 0x04 "chain_status_slp,chain_status_slp"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x04 0. "   mmtx_sleep_ch1    , " "0    ,1    "
      BITFLD.LONG 0x04 1. "   mmtx_sleep_ch2      , " "0    ,1    "
      BITFLD.LONG 0x04 2. "   mmtx_sleep_ch3          , " "0    ,1    "
      BITFLD.LONG 0x04 3. "   mmtx_sleep_ch4       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 4. "   mmtx_sleep_ch5    , " "0    ,1    "
      BITFLD.LONG 0x04 5. "   mmtx_sleep_ch6      , " "0    ,1    "
      BITFLD.LONG 0x04 6. "   mmtx_sleep_ch7          , " "0    ,1    "
      BITFLD.LONG 0x04 7. "   mmtx_sleep_ch8       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 8. "   mmtx_sleep_ch9    , " "0    ,1    "
      BITFLD.LONG 0x04 9. "   lp_stat_s2          , " "0    ,1    "
      BITFLD.LONG 0x04 10. "   lp_stat_s1              , " "0    ,1    "
      BITFLD.LONG 0x04 11. "   lp_stat_s0           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 12. "   lp_stat_main      , " "0    ,1    "
      BITFLD.LONG 0x04 13. "   lp_stat_m9          , " "0    ,1    "
      BITFLD.LONG 0x04 14. "   lp_stat_m8              , " "0    ,1    "
      BITFLD.LONG 0x04 15. "   lp_stat_m7           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 16. "   lp_stat_m6        , " "0    ,1    "
      BITFLD.LONG 0x04 17. "   lp_stat_m5          , " "0    ,1    "
      BITFLD.LONG 0x04 18. "   lp_stat_m4              , " "0    ,1    "
      BITFLD.LONG 0x04 19. "   lp_stat_m3           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 20. "   lp_stat_m2        , " "0    ,1    "
      BITFLD.LONG 0x04 21. "   lp_stat_m1          , " "0    ,1    "
      BITFLD.LONG 0x04 22. "   ap_mtx_pub_deep_stop    , " "0    ,1    "
      BITFLD.LONG 0x04 23. "   mmtx_light_stop      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 24. "   mmtx_deep_stop    , " "0    ,1    "
      BITFLD.LONG 0x04 25. "   ap_peri_sleep       , " "0    ,1    "
      BITFLD.LONG 0x04 26. "   ap_peri_stop            , " "0    ,1    "
      BITFLD.LONG 0x04 27. "   dispc_busy           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 28. "   dma_busy          , " "0    ,1    "
      BITFLD.LONG 0x04 29. "   ca53_top_sys_top    , " "0    ,1    "
      BITFLD.LONG 0x04 30. "   ap_light_sleep_req      , " "0    ,1    "
      BITFLD.LONG 0x04 31. "   ap_deep_sleep_req    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AP @ chain_eb RO"
;-------------------------------------------------
    VARX 0x08 %l DBUS.read(0x00010200)
    TEXTLINE ""
    LINE.LONG 0x08 "chain_eb,chain_eb"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x08 0. "   spi0_eb | spi1_eb | spi2_eb    , " "0    ,1    "
      BITFLD.LONG 0x08 1. "   iis0_eb | iis1_eb | iis3_eb    , " "0    ,1    "
      BITFLD.LONG 0x08 2. "   i2c0_eb | i2c1_eb | i2c2_eb | i2c3_eb | i2c4_eb    , " "0    ,1    "
      BITFLD.LONG 0x08 3. "   uart0_eb | uart1_eb | uart2_eb | uart3_eb | uart4_eb    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 4.--5. "   reserved                       , " "0    ,1    "
      BITFLD.LONG 0x08 6. "   dispc_busy                     , " "0    ,1    "
      BITFLD.LONG 0x08 7. "   dsi_eb                                             , " "0    ,1    "
      BITFLD.LONG 0x08 8. "   dispc_eb                                                , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 9. "   gsp_eb                         , " "0    ,1    "
      BITFLD.LONG 0x08 10. "   nandc_eb                       , " "0    ,1    "
      BITFLD.LONG 0x08 11. "   otg_eb                                             , " "0    ,1    "
      BITFLD.LONG 0x08 12. "   dma_eb                                                  , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 13. "   dma_busy                       , " "0    ,1    "
      BITFLD.LONG 0x08 14. "   sdio0_eb                       , " "0    ,1    "
      BITFLD.LONG 0x08 15. "   sdio1_eb                                           , " "0    ,1    "
      BITFLD.LONG 0x08 16. "   sdio2_eb                                                , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 17. "   emmc_eb                        , " "0    ,1    "
    SGROUP "AP @ chain_lp_clk RO"
;-------------------------------------------------
    VARX 0x0C %l DBUS.read(0x00010300)
    TEXTLINE ""
    LINE.LONG 0x0C "chain_lp_clk,chain_lp_clk"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x0C 0. "   lp_stat_s5       , " "0    ,1    "
      BITFLD.LONG 0x0C 1. "   lp_stat_s4       , " "0    ,1    "
      BITFLD.LONG 0x0C 2. "   lp_stat_s3         , " "0    ,1    "
      BITFLD.LONG 0x0C 3. "   lp_stat_s2       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 4. "   lp_stat_s1       , " "0    ,1    "
      BITFLD.LONG 0x0C 5. "   lp_stat_s0       , " "0    ,1    "
      BITFLD.LONG 0x0C 6. "   lp_stat_main       , " "0    ,1    "
      BITFLD.LONG 0x0C 7. "   lp_stat_m9       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 8. "   lp_stat_m8       , " "0    ,1    "
      BITFLD.LONG 0x0C 9. "   lp_stat_m7       , " "0    ,1    "
      BITFLD.LONG 0x0C 10. "   lp_stat_m6         , " "0    ,1    "
      BITFLD.LONG 0x0C 11. "   lp_stat_m5       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 12. "   lp_stat_m4       , " "0    ,1    "
      BITFLD.LONG 0x0C 13. "   lp_stat_m3       , " "0    ,1    "
      BITFLD.LONG 0x0C 14. "   lp_stat_m2         , " "0    ,1    "
      BITFLD.LONG 0x0C 15. "   lp_stat_m1       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 16. "   clk_ap_s5_clk    , " "0    ,1    "
      BITFLD.LONG 0x0C 17. "   clk_ap_s4_clk    , " "0    ,1    "
      BITFLD.LONG 0x0C 18. "   clk_ap_s3_clk      , " "0    ,1    "
      BITFLD.LONG 0x0C 19. "   clk_ap_s2_clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 20. "   clk_ap_s1_clk    , " "0    ,1    "
      BITFLD.LONG 0x0C 21. "   clk_ap_s0_clk    , " "0    ,1    "
      BITFLD.LONG 0x0C 22. "   clk_ap_main_clk    , " "0    ,1    "
      BITFLD.LONG 0x0C 23. "   clk_ap_m9_clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 24. "   clk_ap_m8_clk    , " "0    ,1    "
      BITFLD.LONG 0x0C 25. "   clk_ap_m7_clk    , " "0    ,1    "
      BITFLD.LONG 0x0C 26. "   clk_ap_m6_clk      , " "0    ,1    "
      BITFLD.LONG 0x0C 27. "   clk_ap_m5_clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 28. "   clk_ap_m4_clk    , " "0    ,1    "
      BITFLD.LONG 0x0C 29. "   clk_ap_m3_clk    , " "0    ,1    "
      BITFLD.LONG 0x0C 30. "   clk_ap_m2_clk      , " "0    ,1    "
      BITFLD.LONG 0x0C 31. "   clk_ap_m1_clk    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AP @ chain_brg_master RO"
;-------------------------------------------------
    VARX 0x10 %l DBUS.read(0x00010400)
    TEXTLINE ""
    LINE.LONG 0x10 "chain_brg_master,chain_brg_master"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x10 0. "   clk_ap_m8_clk    , " "0    ,1    "
      BITFLD.LONG 0x10 1. "   csysack_m8    , " "0    ,1    "
      BITFLD.LONG 0x10 2. "   csysreq_m8    , " "0    ,1    "
      BITFLD.LONG 0x10 3. "   cative_m8    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 4. "   clk_ap_m7_clk    , " "0    ,1    "
      BITFLD.LONG 0x10 5. "   csysack_m7    , " "0    ,1    "
      BITFLD.LONG 0x10 6. "   csysreq_m7    , " "0    ,1    "
      BITFLD.LONG 0x10 7. "   cative_m7    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 8. "   clk_ap_m6_clk    , " "0    ,1    "
      BITFLD.LONG 0x10 9. "   csysack_m6    , " "0    ,1    "
      BITFLD.LONG 0x10 10. "   csysreq_m6    , " "0    ,1    "
      BITFLD.LONG 0x10 11. "   cative_m6    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 12. "   clk_ap_m5_clk    , " "0    ,1    "
      BITFLD.LONG 0x10 13. "   csysack_m5    , " "0    ,1    "
      BITFLD.LONG 0x10 14. "   csysreq_m5    , " "0    ,1    "
      BITFLD.LONG 0x10 15. "   cative_m5    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 16. "   clk_ap_m4_clk    , " "0    ,1    "
      BITFLD.LONG 0x10 17. "   csysack_m4    , " "0    ,1    "
      BITFLD.LONG 0x10 18. "   csysreq_m4    , " "0    ,1    "
      BITFLD.LONG 0x10 19. "   cative_m4    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 20. "   clk_ap_m3_clk    , " "0    ,1    "
      BITFLD.LONG 0x10 21. "   csysack_m3    , " "0    ,1    "
      BITFLD.LONG 0x10 22. "   csysreq_m3    , " "0    ,1    "
      BITFLD.LONG 0x10 23. "   cative_m3    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 24. "   clk_ap_m2_clk    , " "0    ,1    "
      BITFLD.LONG 0x10 25. "   csysack_m2    , " "0    ,1    "
      BITFLD.LONG 0x10 26. "   csysreq_m2    , " "0    ,1    "
      BITFLD.LONG 0x10 27. "   cative_m2    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 28. "   clk_ap_m1_clk    , " "0    ,1    "
      BITFLD.LONG 0x10 29. "   csysack_m1    , " "0    ,1    "
      BITFLD.LONG 0x10 30. "   csysreq_m1    , " "0    ,1    "
      BITFLD.LONG 0x10 31. "   cative_m1    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AP @ chain_brg_slave RO"
;-------------------------------------------------
    VARX 0x14 %l DBUS.read(0x00010500)
    TEXTLINE ""
    LINE.LONG 0x14 "chain_brg_slave,chain_brg_slave"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x14 0. "   clk_ap_s5_clk      , " "0    ,1    "
      BITFLD.LONG 0x14 1. "   csysack_s5      , " "0    ,1    "
      BITFLD.LONG 0x14 2. "   csysreq_s5      , " "0    ,1    "
      BITFLD.LONG 0x14 3. "   cative_s5      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 4. "   clk_ap_s4_clk      , " "0    ,1    "
      BITFLD.LONG 0x14 5. "   csysack_s4      , " "0    ,1    "
      BITFLD.LONG 0x14 6. "   csysreq_s4      , " "0    ,1    "
      BITFLD.LONG 0x14 7. "   cative_s4      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 8. "   clk_ap_s3_clk      , " "0    ,1    "
      BITFLD.LONG 0x14 9. "   csysack_s3      , " "0    ,1    "
      BITFLD.LONG 0x14 10. "   csysreq_s3      , " "0    ,1    "
      BITFLD.LONG 0x14 11. "   cative_s3      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 12. "   clk_ap_s2_clk      , " "0    ,1    "
      BITFLD.LONG 0x14 13. "   csysack_s2      , " "0    ,1    "
      BITFLD.LONG 0x14 14. "   csysreq_s2      , " "0    ,1    "
      BITFLD.LONG 0x14 15. "   cative_s2      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 16. "   clk_ap_s1_clk      , " "0    ,1    "
      BITFLD.LONG 0x14 17. "   csysack_s1      , " "0    ,1    "
      BITFLD.LONG 0x14 18. "   csysreq_s1      , " "0    ,1    "
      BITFLD.LONG 0x14 19. "   cative_s1      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 20. "   clk_ap_s0_clk      , " "0    ,1    "
      BITFLD.LONG 0x14 21. "   csysack_s0      , " "0    ,1    "
      BITFLD.LONG 0x14 22. "   csysreq_s0      , " "0    ,1    "
      BITFLD.LONG 0x14 23. "   cative_s0      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 24. "   clk_ap_main_clk    , " "0    ,1    "
      BITFLD.LONG 0x14 25. "   csysack_main    , " "0    ,1    "
      BITFLD.LONG 0x14 26. "   csysreq_main    , " "0    ,1    "
      BITFLD.LONG 0x14 27. "   cative_main    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 28. "   clk_ap_m9_clk      , " "0    ,1    "
      BITFLD.LONG 0x14 29. "   csysack_m9      , " "0    ,1    "
      BITFLD.LONG 0x14 30. "   csysreq_m9      , " "0    ,1    "
      BITFLD.LONG 0x14 31. "   cative_m9      , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AP @ chain_brg_slave1 RO"
;-------------------------------------------------
    VARX 0x18 %l DBUS.read(0x00010600)
    TEXTLINE ""
    LINE.LONG 0x18 "chain_brg_slave1,chain_brg_slave1"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x18 0. "   clk_ap_m8_clk      , " "0    ,1    "
      BITFLD.LONG 0x18 1. "   csysack_m8      , " "0    ,1    "
      BITFLD.LONG 0x18 2. "   csysreq_m8      , " "0    ,1    "
      BITFLD.LONG 0x18 3. "   cative_m8      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 4. "   clk_ap_m1_clk      , " "0    ,1    "
      BITFLD.LONG 0x18 5. "   csysack_m1      , " "0    ,1    "
      BITFLD.LONG 0x18 6. "   csysreq_m1      , " "0    ,1    "
      BITFLD.LONG 0x18 7. "   cative_m1      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 8. "   clk_ap_m6_clk      , " "0    ,1    "
      BITFLD.LONG 0x18 9. "   csysack_m6      , " "0    ,1    "
      BITFLD.LONG 0x18 10. "   csysreq_m6      , " "0    ,1    "
      BITFLD.LONG 0x18 11. "   cative_m6      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 12. "   clk_ap_m5_clk      , " "0    ,1    "
      BITFLD.LONG 0x18 13. "   csysack_m5      , " "0    ,1    "
      BITFLD.LONG 0x18 14. "   csysreq_m5      , " "0    ,1    "
      BITFLD.LONG 0x18 15. "   cative_m5      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 16. "   clk_ap_s3_clk      , " "0    ,1    "
      BITFLD.LONG 0x18 17. "   csysack_s3      , " "0    ,1    "
      BITFLD.LONG 0x18 18. "   csysreq_s3      , " "0    ,1    "
      BITFLD.LONG 0x18 19. "   cative_s3      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 20. "   clk_ap_s5_clk      , " "0    ,1    "
      BITFLD.LONG 0x18 21. "   csysack_s5      , " "0    ,1    "
      BITFLD.LONG 0x18 22. "   csysreq_s5      , " "0    ,1    "
      BITFLD.LONG 0x18 23. "   cative_s5      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 24. "   clk_ap_main_clk    , " "0    ,1    "
      BITFLD.LONG 0x18 25. "   csysack_main    , " "0    ,1    "
      BITFLD.LONG 0x18 26. "   csysreq_main    , " "0    ,1    "
      BITFLD.LONG 0x18 27. "   cative_main    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 28. "   clk_ap_m10_clk     , " "0    ,1    "
      BITFLD.LONG 0x18 29. "   csysack_m10     , " "0    ,1    "
      BITFLD.LONG 0x18 30. "   csysreq_m10     , " "0    ,1    "
      BITFLD.LONG 0x18 31. "   cative_m10     , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AP @ chain_clk_ap RO"
;-------------------------------------------------
    VARX 0x1C %l DBUS.read(0x00010700)
    TEXTLINE ""
    LINE.LONG 0x1C "chain_clk_ap,chain_clk_ap"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x1C 0. "   clk_iis1         , " "0    ,1    "
      BITFLD.LONG 0x1C 1. "   clk_iis0            , " "0    ,1    "
      BITFLD.LONG 0x1C 2. "   clk_spi2         , " "0    ,1    "
      BITFLD.LONG 0x1C 3. "   clk_spi1         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 4. "   clk_spi0         , " "0    ,1    "
      BITFLD.LONG 0x1C 5. "   clk_i2c4            , " "0    ,1    "
      BITFLD.LONG 0x1C 6. "   clk_i2c3         , " "0    ,1    "
      BITFLD.LONG 0x1C 7. "   clk_i2c2         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 8. "   clk_i2c1         , " "0    ,1    "
      BITFLD.LONG 0x1C 9. "   clk_i2c0            , " "0    ,1    "
      BITFLD.LONG 0x1C 10. "   clk_uart4        , " "0    ,1    "
      BITFLD.LONG 0x1C 11. "   clk_uart3        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 12. "   clk_uart2        , " "0    ,1    "
      BITFLD.LONG 0x1C 13. "   clk_uart1           , " "0    ,1    "
      BITFLD.LONG 0x1C 14. "   clk_uart0        , " "0    ,1    "
      BITFLD.LONG 0x1C 15. "   clk_otg_utmi     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 16.--18. "   reserved         , " "0    ,1    "
      BITFLD.LONG 0x1C 19. "   clk_dsi_lanebyte    , " "0    ,1    "
      BITFLD.LONG 0x1C 20. "   clk_dsi_rxesc    , " "0    ,1    "
      BITFLD.LONG 0x1C 21. "   clk_dispc_dsi    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 22. "   clk_dispc        , " "0    ,1    "
      BITFLD.LONG 0x1C 23. "   clk_gsp             , " "0    ,1    "
      BITFLD.LONG 0x1C 24. "   clk_sim0_32k     , " "0    ,1    "
      BITFLD.LONG 0x1C 25. "   clk_sdio2_32k    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 26. "   clk_sdio1_32k    , " "0    ,1    "
      BITFLD.LONG 0x1C 27. "   clk_sdio0_32k       , " "0    ,1    "
      BITFLD.LONG 0x1C 28. "   clk_emmc_32k     , " "0    ,1    "
      BITFLD.LONG 0x1C 29. "   clk_ce_sec       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 30. "   clk_ce_efuse     , " "0    ,1    "
      BITFLD.LONG 0x1C 31. "   clk_ap_apb          , " "0    ,1    "
    SGROUP "AP @ chain_clk_ap1 RO"
;-------------------------------------------------
    VARX 0x20 %l DBUS.read(0x00010800)
    TEXTLINE ""
    LINE.LONG 0x20 "chain_clk_ap1,chain_clk_ap1"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x20 16. "   clk_nandc_ecc        , " "0    ,1    "
      BITFLD.LONG 0x20 17. "   clk_nandc        , " "0    ,1    "
      BITFLD.LONG 0x20 18. "   pclk_tzpc_ap       , " "0    ,1    "
      BITFLD.LONG 0x20 19. "   cllk_sdio2         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 20. "   clk_sdio0            , " "0    ,1    "
      BITFLD.LONG 0x20 21. "   clk_emmc         , " "0    ,1    "
      BITFLD.LONG 0x20 22. "   clk_axi_pub        , " "0    ,1    "
      BITFLD.LONG 0x20 23. "   clk_axi_gsp_emc    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 24. "   clk_axi_dispc_emc    , " "0    ,1    "
      BITFLD.LONG 0x20 25. "   clk_ap_axi       , " "0    ,1    "
      BITFLD.LONG 0x20 26. "   clk_axi_gsp_emc    , " "0    ,1    "
      BITFLD.LONG 0x20 27. "   clk_axi_ap_emc     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 28. "   clk_bist_256m        , " "0    ,1    "
      BITFLD.LONG 0x20 29. "   clk_bist_192m    , " "0    ,1    "
      BITFLD.LONG 0x20 30. "   clk_iis3           , " "0    ,1    "
      BITFLD.LONG 0x20 31. "   clk_iis2           , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AP @ chain_sleep_ap RO"
;-------------------------------------------------
    VARX 0x24 %l DBUS.read(0x00010900)
    TEXTLINE ""
    LINE.LONG 0x24 "chain_sleep_ap,chain_sleep_ap"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x24 0. "   lp_stat_m10             , " "0    ,1    "
      BITFLD.LONG 0x24 1. "   mmtx_sleep_ch10         , " "0    ,1    "
      BITFLD.LONG 0x24 2. "   m10_lp_eb            , " "0    ,1    "
      BITFLD.LONG 0x24 3. "   nandc_eb_lp       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x24 4. "   ap_peri_stop            , " "0    ,1    "
      BITFLD.LONG 0x24 5. "   dispc_busy              , " "0    ,1    "
      BITFLD.LONG 0x24 6. "   dispc_eb             , " "0    ,1    "
      BITFLD.LONG 0x24 7. "   gsp_eb            , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x24 8. "   ap_peri_force_on        , " "0    ,1    "
      BITFLD.LONG 0x24 9. "   ap_apb_sleep            , " "0    ,1    "
      BITFLD.LONG 0x24 10. "   ap_peri_force_slp    , " "0    ,1    "
      BITFLD.LONG 0x24 11. "   ap_peri_sleep     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x24 12. "   ap_mtx_pub_deep_stop    , " "0    ,1    "
      BITFLD.LONG 0x24 13. "   ap_mtx_pub_deep_stop    , " "0    ,1    "
      BITFLD.LONG 0x24 14. "   mmtx_light_stop      , " "0    ,1    "
      BITFLD.LONG 0x24 15. "   mmtx_deep_stop    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x24 16. "   slv_sleep_ch5           , " "0    ,1    "
      BITFLD.LONG 0x24 17. "   slv_sleep_ch4           , " "0    ,1    "
      BITFLD.LONG 0x24 18. "   slv_sleep_ch3        , " "0    ,1    "
      BITFLD.LONG 0x24 19. "   slv_sleep_ch2     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x24 20. "   slv_sleep_ch1           , " "0    ,1    "
      BITFLD.LONG 0x24 21. "   slv_sleep_ch0           , " "0    ,1    "
      BITFLD.LONG 0x24 22. "   mmtx_sleep_ch10      , " "0    ,1    "
      BITFLD.LONG 0x24 23. "   mmtx_sleep_ch9    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x24 24. "   mmtx_sleep_ch8          , " "0    ,1    "
      BITFLD.LONG 0x24 25. "   mmtx_sleep_ch7          , " "0    ,1    "
      BITFLD.LONG 0x24 26. "   mmtx_sleep_ch6       , " "0    ,1    "
      BITFLD.LONG 0x24 27. "   mmtx_sleep_ch5    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x24 28. "   mmtx_sleep_ch4          , " "0    ,1    "
      BITFLD.LONG 0x24 29. "   mmtx_sleep_ch3          , " "0    ,1    "
      BITFLD.LONG 0x24 30. "   mmtx_sleep_ch2       , " "0    ,1    "
      BITFLD.LONG 0x24 31. "   mmtx_sleep_ch1    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AP @ chain_sleep_ap1 RO"
;-------------------------------------------------
    VARX 0x28 %l DBUS.read(0x00010A00)
    TEXTLINE ""
    LINE.LONG 0x28 "chain_sleep_ap1,chain_sleep_ap1"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x28 0. "   lp_stat_m9    , " "0    ,1    "
      BITFLD.LONG 0x28 1. "   mmtx_sleep_ch9        , " "0    ,1    "
      BITFLD.LONG 0x28 2. "   m9_lp_eb    , " "0    ,1    "
      BITFLD.LONG 0x28 3. "   ce_sec_eb_lp    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x28 4. "   lp_stat_m8    , " "0    ,1    "
      BITFLD.LONG 0x28 5. "   mmtx_sleep_ch8        , " "0    ,1    "
      BITFLD.LONG 0x28 6. "   m8_lp_eb    , " "0    ,1    "
      BITFLD.LONG 0x28 7. "   otg_eb_lp       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x28 8. "   lp_stat_m7    , " "0    ,1    "
      BITFLD.LONG 0x28 9. "   mmtx_sleep_ch7        , " "0    ,1    "
      BITFLD.LONG 0x28 10. "   m7_lp_eb    , " "0    ,1    "
      BITFLD.LONG 0x28 11. "   emmc_eb_lp      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x28 12. "   lp_stat_m6    , " "0    ,1    "
      BITFLD.LONG 0x28 13. "   mmtx_sleep_ch6        , " "0    ,1    "
      BITFLD.LONG 0x28 14. "   m6_lp_eb    , " "0    ,1    "
      BITFLD.LONG 0x28 15. "   sdio2_eb_lp     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x28 16. "   lp_stat_m5    , " "0    ,1    "
      BITFLD.LONG 0x28 17. "   mmtx_sleep_ch5        , " "0    ,1    "
      BITFLD.LONG 0x28 18. "   m5_lp_eb    , " "0    ,1    "
      BITFLD.LONG 0x28 19. "   sdio1_eb_lp     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x28 20. "   lp_stat_m4    , " "0    ,1    "
      BITFLD.LONG 0x28 21. "   mmtx_sleep_ch4        , " "0    ,1    "
      BITFLD.LONG 0x28 22. "   m4_lp_eb    , " "0    ,1    "
      BITFLD.LONG 0x28 23. "   sdio0_eb_lp     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x28 24. "   lp_stat_m3    , " "0    ,1    "
      BITFLD.LONG 0x28 25. "   mmtx_sleep_ch3        , " "0    ,1    "
      BITFLD.LONG 0x28 26. "   m3_lp_eb    , " "0    ,1    "
      BITFLD.LONG 0x28 27. "   ce_pub_eb_lp    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x28 28. "   lp_stat_m2    , " "0    ,1    "
      BITFLD.LONG 0x28 29. "   mmtx-sleep_ch2_lpc    , " "0    ,1    "
      BITFLD.LONG 0x28 30. "   m2_lp_eb    , " "0    ,1    "
      BITFLD.LONG 0x28 31. "   dma_eb_lp       , " "0    ,1    "
    TEXTLINE ""
TREE.END
;###################Tree###################
TREE "CA53"
    SGROUP "CA53 @ chain_big_lit RO"
;-------------------------------------------------
    VARX 0x04 %l DBUS.read(0x00020000)
    TEXTLINE ""
    LINE.LONG 0x04 "chain_big_lit,chain_big_lit"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x04 0. "   ca53_top_sys_stop      , " "0    ,1    "
      BITFLD.LONG 0x04 1. "   STANBYWFIL2_LIT                 , " "0    ,1    "
      BITFLD.LONG 0x04 2. "   STANBYWFIL2_BIG               , " "0    ,1    "
      BITFLD.LONG 0x04 3. "   gpu_en                 , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 4. "   csyspwrup              , " "0    ,1    "
      BITFLD.LONG 0x04 5. "   lit_l2_victimram_light_sleep    , " "0    ,1    "
      BITFLD.LONG 0x04 6. "   lit_l2_dataram_light_sleep    , " "0    ,1    "
      BITFLD.LONG 0x04 7. "   lit_adb400_cactives    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 8. "   lit_adb400_cactivem    , " "0    ,1    "
      BITFLD.LONG 0x04 9. "   big_l2_victimram_light_sleep    , " "0    ,1    "
      BITFLD.LONG 0x04 10. "   big_l2_dataram_light_sleep    , " "0    ,1    "
      BITFLD.LONG 0x04 11. "   big_adb400_cactives    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 12. "   big_adb400_cactivem    , " "0    ,1    "
    SGROUP "CA53 @ chain_lit1 RO"
;-------------------------------------------------
    VARX 0x08 %l DBUS.read(0x00020001)
    TEXTLINE ""
    LINE.LONG 0x08 "chain_lit1,chain_lit1"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x08 0.--1. "   ca53_lit_core_stop[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x08 2.--3. "   STANDBYWFI_LIT[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x08 4.--5. "   SMPEN_LIT[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x08 6.--7. "   DBGPWRUPREQ_LIT[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    TEXTLINE ""
    SGROUP "CA53 @ chain_big1 RO"
;-------------------------------------------------
    VARX 0x0C %l DBUS.read(0x00020002)
    TEXTLINE ""
    LINE.LONG 0x0C "chain_big1,chain_big1"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x0C 0.--1. "   ca53_big_core_stop[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x0C 2.--3. "   STANDBYWFI_BIG[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x0C 4.--5. "   SMPEN_BIG[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x0C 6.--7. "   DBGPWRUPREQ_BIG[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    TEXTLINE ""
    SGROUP "CA53 @ chain_int_cpu RO"
;-------------------------------------------------
    VARX 0x10 %l DBUS.read(0x00020003)
    TEXTLINE ""
    LINE.LONG 0x10 "chain_int_cpu,chain_int_cpu"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x10 0.--5. "   nIRQCPU[5:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
      BITFLD.LONG 0x10 6.--11. "   nFIQCPU[5:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
    SGROUP "CA53 @ chain_nic_cci RO"
;-------------------------------------------------
    VARX 0x14 %l DBUS.read(0x00020004)
    TEXTLINE ""
    LINE.LONG 0x14 "chain_nic_cci,chain_nic_cci"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x14 0. "   nic_slp_req_m0    , " "0    ,1    "
      BITFLD.LONG 0x14 1. "   reserve                , " "0    ,1    "
      BITFLD.LONG 0x14 2. "   nic_slp_req_s0         , " "0    ,1    "
      BITFLD.LONG 0x14 3. "   nic_slp_req_s1    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 4. "   nic_slp_req_s2    , " "0    ,1    "
      BITFLD.LONG 0x14 5. "   nic_slp_req_s3         , " "0    ,1    "
      BITFLD.LONG 0x14 6.--7. "   reserve                , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x14 8. "   cci_slp_req       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 9.--10. "   reserve           , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x14 11. "   nic_lp_ctrl_disable    , " "0    ,1    "
      BITFLD.LONG 0x14 12. "   cci_lp_ctrl_disable    , " "0    ,1    "
    SGROUP "CA53 @ chain_slp_stop RO"
;-------------------------------------------------
    VARX 0x18 %l DBUS.read(0x00020005)
    TEXTLINE ""
    LINE.LONG 0x18 "chain_slp_stop,chain_slp_stop"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x18 0. "   nic_slp_stop_m0    , " "0    ,1    "
      BITFLD.LONG 0x18 1. "   reserve            , " "0    ,1    "
      BITFLD.LONG 0x18 2. "   nic_slp_stop_s0    , " "0    ,1    "
      BITFLD.LONG 0x18 3. "   nic_slp_stop_s1    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 4. "   nic_slp_stop_s2    , " "0    ,1    "
      BITFLD.LONG 0x18 5. "   nic_slp_stop_s3    , " "0    ,1    "
      BITFLD.LONG 0x18 6.--7. "   reserve            , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x18 8. "   cci_slp_stop       , " "0    ,1    "
    TEXTLINE ""
    SGROUP "CA53 @ chain_nic_en RO"
;-------------------------------------------------
    VARX 0x1C %l DBUS.read(0x00020006)
    TEXTLINE ""
    LINE.LONG 0x1C "chain_nic_en,chain_nic_en"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x1C 0. "   nic_m0_clk_en                , " "0    ,1    "
      BITFLD.LONG 0x1C 1. "   reserve                      , " "0    ,1    "
      BITFLD.LONG 0x1C 2. "   nic_s0_clk_en    , " "0    ,1    "
      BITFLD.LONG 0x1C 3. "   nic_s1_clk_en                    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 4. "   nic_s2_clk_en                , " "0    ,1    "
      BITFLD.LONG 0x1C 5. "   nic_s3_clk_en                , " "0    ,1    "
      BITFLD.LONG 0x1C 6.--7. "   reserve          , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x1C 8. "   cci_clk_en                       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 9. "   reserve                      , " "0    ,1    "
      BITFLD.LONG 0x1C 10. "   dap2cci_clk_en               , " "0    ,1    "
      BITFLD.LONG 0x1C 11. "   reserve          , " "0    ,1    "
      BITFLD.LONG 0x1C 12. "   dap2cci_auto_clk_ctrl_disable    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 13. "   nic_auto_clk_ctrl_disable    , " "0    ,1    "
      BITFLD.LONG 0x1C 14. "   cci_auto_clk_ctrl_disable    , " "0    ,1    "
    SGROUP "CA53 @ chain_core_en RO"
;-------------------------------------------------
    VARX 0x20 %l DBUS.read(0x00020007)
    TEXTLINE ""
    LINE.LONG 0x20 "chain_core_en,chain_core_en"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x20 0. "   ca53_big_core_en_vld    , " "0    ,1    "
      BITFLD.LONG 0x20 1. "   ca53_big_core_en                  , " "0    ,1    "
      BITFLD.LONG 0x20 2. "   ca53_big_dbg_en_vld               , " "0    ,1    "
      BITFLD.LONG 0x20 3. "   ca53_big_dbg_en         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 4. "   ca53_big_atb_en_vld     , " "0    ,1    "
      BITFLD.LONG 0x20 5. "   ca53_big_atb_en                   , " "0    ,1    "
      BITFLD.LONG 0x20 6. "   ca53_big_auto_clk_ctrl_disable    , " "0    ,1    "
      BITFLD.LONG 0x20 7. "   ca53_lit_core_en_vld    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 8. "   ca53_lit_core_en        , " "0    ,1    "
      BITFLD.LONG 0x20 9. "   ca53_lit_dbg_en_vld               , " "0    ,1    "
      BITFLD.LONG 0x20 10. "   ca53_lit_dbg_en                   , " "0    ,1    "
      BITFLD.LONG 0x20 11. "   ca53_lit_atb_en_vld     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 12. "   ca53_lit_atb_en         , " "0    ,1    "
      BITFLD.LONG 0x20 13. "   ca53_lit_auto_clk_ctrl_disable    , " "0    ,1    "
    SGROUP "CA53 @ chain_core_cgm RO"
;-------------------------------------------------
    VARX 0x24 %l DBUS.read(0x00020008)
    TEXTLINE ""
    LINE.LONG 0x24 "chain_core_cgm,chain_core_cgm"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x24 0. "   cgm_busy_big_mcu_mux    , " "0    ,1    "
      BITFLD.LONG 0x24 1. "   cgm_busy_lit_mcu_mux    , " "0    ,1    "
    SGROUP "CA53 @ chain_busmon_ca53 RO"
;-------------------------------------------------
    VARX 0x28 %l DBUS.read(0x00020009)
    TEXTLINE ""
    LINE.LONG 0x28 "chain_busmon_ca53,chain_busmon_ca53"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x28 0. "   bus_busy_ddr    , " "0    ,1    "
      BITFLD.LONG 0x28 1. "   bus_busy_nic    , " "0    ,1    "
      BITFLD.LONG 0x28 2. "   int_req_busmon_ddr    , " "0    ,1    "
      BITFLD.LONG 0x28 3. "   int_req_busmon_nic    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "CA53 @ chain_jvl RO"
;-------------------------------------------------
    VARX 0x2C %l DBUS.read(0x0002000A)
    TEXTLINE ""
    LINE.LONG 0x2C "chain_jvl,chain_jvl"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x2C 0.--3. "   nFIQOUT_GIC[5:2]            , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x2C 4.--7. "   nIRQOUT_GIC[5:2]            , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x2C 8.--9. "   Jvl_c1_Force_kick[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x2C 10.--11. "   Jvl_c0_Force_kick[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    TEXTLINE ""
      BITFLD.LONG 0x2C 12.--13. "   Jvl_c1_Auto_kick_en[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x2C 14.--15. "   Jvl_c0_Auto_kick_en[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
TREE.END
;###################Tree###################
TREE "GPU"
    SGROUP "GPU @ chain_gpu RO"
;-------------------------------------------------
    VARX 0x04 %l DBUS.read(0x00030200)
    TEXTLINE ""
    LINE.LONG 0x04 "chain_gpu,chain_gpu"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x04 0. "   DRAM path hardware decided    , 1: hardware decided" "0    ,1    "
      BITFLD.LONG 0x04 1. "   Read access DRAM path    , 0: through CCI    1: through GSP matrix" "0    ,1    "
      BITFLD.LONG 0x04 2. "   Write access DRAM path    , 0: through CCI    1: through GSP matrix" "0    ,1    "
      BITFLD.LONG 0x04 3. "   IRQGPU    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 4. "   IRQMMU                        , " "0    ,1    "
      BITFLD.LONG 0x04 5. "   IRQJOB                   , " "0    ,1    "
TREE.END
;###################Tree###################
TREE "PUB"
    SGROUP "PUB @ chain_ddr_scan RO"
;-------------------------------------------------
    VARX 0x04 %l DBUS.read(0x00040001)
    TEXTLINE ""
    LINE.LONG 0x04 "chain_ddr_scan,chain_ddr_scan"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x04 0. "   clk_dwc_ddr_umctl_scan    , " "0    ,1    "
      BITFLD.LONG 0x04 1. "   clk_dwc_ddr_umctl_2x_scan    , " "0    ,1    "
    SGROUP "PUB @ chain_dmc_dbg RO"
;-------------------------------------------------
    VARX 0x08 %l DBUS.read(0x00040002)
    TEXTLINE ""
    LINE.LONG 0x08 "chain_dmc_dbg,chain_dmc_dbg"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x08 0.--17. "   c_chn_dbg_in    , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
      BITFLD.LONG 0x08 18. "   dmc_stop    , " "0    ,1    "
      BITFLD.LONG 0x08 19. "   dmc_sleep    , " "0    ,1    "
      BITFLD.LONG 0x08 20.--31. "   lpc_dbg[11:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
    TEXTLINE ""
    SGROUP "PUB @ chain_dmc_status RO"
;-------------------------------------------------
    VARX 0x0C %l DBUS.read(0x00040003)
    TEXTLINE ""
    LINE.LONG 0x0C "chain_dmc_status,chain_dmc_status"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x0C 0. "   dmc_stop_ch7     , " "0    ,1    "
      BITFLD.LONG 0x0C 1. "   dmc_stop_ch6     , " "0    ,1    "
      BITFLD.LONG 0x0C 2. "   dmc_stop_ch5     , " "0    ,1    "
      BITFLD.LONG 0x0C 3. "   dmc_stop_ch4     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 4. "   dmc_stop_ch3     , " "0    ,1    "
      BITFLD.LONG 0x0C 5. "   dmc_stop_ch2     , " "0    ,1    "
      BITFLD.LONG 0x0C 6. "   dmc_stop_ch1     , " "0    ,1    "
      BITFLD.LONG 0x0C 7. "   dmc_stop_ch0     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 8. "   dmc_sleep_ch7    , " "0    ,1    "
      BITFLD.LONG 0x0C 9. "   dmc_sleep_ch6    , " "0    ,1    "
      BITFLD.LONG 0x0C 10. "   dmc_sleep_ch5    , " "0    ,1    "
      BITFLD.LONG 0x0C 11. "   dmc_sleep_ch4    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 12. "   dmc_sleep_ch3    , " "0    ,1    "
      BITFLD.LONG 0x0C 13. "   dmc_sleep_ch2    , " "0    ,1    "
      BITFLD.LONG 0x0C 14. "   dmc_sleep_ch1    , " "0    ,1    "
      BITFLD.LONG 0x0C 15. "   dmc_sleep_ch0    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 16. "   CRACTIVE7        , " "0    ,1    "
      BITFLD.LONG 0x0C 17. "   CWACTIVE7        , " "0    ,1    "
      BITFLD.LONG 0x0C 18. "   CRACTIVE6        , " "0    ,1    "
      BITFLD.LONG 0x0C 19. "   CWACTIVE6        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 20. "   CRACTIVE5        , " "0    ,1    "
      BITFLD.LONG 0x0C 21. "   CWACTIVE5        , " "0    ,1    "
      BITFLD.LONG 0x0C 22. "   CRACTIVE4        , " "0    ,1    "
      BITFLD.LONG 0x0C 23. "   CWACTIVE4        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 24. "   CRACTIVE3        , " "0    ,1    "
      BITFLD.LONG 0x0C 25. "   CWACTIVE3        , " "0    ,1    "
      BITFLD.LONG 0x0C 26. "   CRACTIVE2        , " "0    ,1    "
      BITFLD.LONG 0x0C 27. "   CWACTIVE2        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 28. "   CRACTIVE1        , " "0    ,1    "
      BITFLD.LONG 0x0C 20. "   CWACTIVE1        , " "0    ,1    "
      BITFLD.LONG 0x0C 30. "   CRACTIVE0        , " "0    ,1    "
      BITFLD.LONG 0x0C 31. "   CWACTIVE0        , " "0    ,1    "
    TEXTLINE ""
    SGROUP "PUB @ chain_dmc_lp RO"
;-------------------------------------------------
    VARX 0x10 %l DBUS.read(0x00040004)
    TEXTLINE ""
    LINE.LONG 0x10 "chain_dmc_lp,chain_dmc_lp"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x10 0.--6. "   reserve            , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
      BITFLD.LONG 0x10 7.--8. "   soft_cmd_fc_sel[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x10 9. "   soft_cmd_start    , " "0    ,1    "
      BITFLD.LONG 0x10 10.--11. "   dmc_lp_reg_sel[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    TEXTLINE ""
      BITFLD.LONG 0x10 12.--19. "   dmc_lp_cmd[7:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
      BITFLD.LONG 0x10 20. "   lp_cmd_valid            , " "0    ,1    "
      BITFLD.LONG 0x10 21. "   dmc_lp_req        , " "0    ,1    "
      BITFLD.LONG 0x10 22. "   dmc_lp_resp            , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 23. "   dmc_lp_done        , " "0    ,1    "
      BITFLD.LONG 0x10 24. "   dmc_lp_ack              , " "0    ,1    "
      BITFLD.LONG 0x10 25. "   dmc_resp          , " "0    ,1    "
      BITFLD.LONG 0x10 26.--27. "   dfs_fc_sel[1:0]        , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    TEXTLINE ""
      BITFLD.LONG 0x10 28. "   dfs_fc_ack         , " "0    ,1    "
      BITFLD.LONG 0x10 29. "   dfs_fc_req              , " "0    ,1    "
      BITFLD.LONG 0x10 30. "   dfds_ack          , " "0    ,1    "
      BITFLD.LONG 0x10 31. "   dfs_req                , " "0    ,1    "
    TEXTLINE ""
    SGROUP "PUB @ chain_bus_status RO"
;-------------------------------------------------
    VARX 0x14 %l DBUS.read(0x00040005)
    TEXTLINE ""
    LINE.LONG 0x14 "chain_bus_status,chain_bus_status"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x14 0. "   BVALID0     , " "0    ,1    "
      BITFLD.LONG 0x14 1. "   RVALID0     , " "0    ,1    "
      BITFLD.LONG 0x14 2. "   WREADY0     , " "0    ,1    "
      BITFLD.LONG 0x14 3. "   WVALID0     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 4. "   ARREADY0    , " "0    ,1    "
      BITFLD.LONG 0x14 5. "   ARVALID0    , " "0    ,1    "
      BITFLD.LONG 0x14 6. "   AWREADY0    , " "0    ,1    "
      BITFLD.LONG 0x14 7. "   AWVALID0    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 8. "   BVALID1     , " "0    ,1    "
      BITFLD.LONG 0x14 9. "   RVALID1     , " "0    ,1    "
      BITFLD.LONG 0x14 10. "   WREADY1     , " "0    ,1    "
      BITFLD.LONG 0x14 11. "   WVALID1     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 12. "   ARREADY1    , " "0    ,1    "
      BITFLD.LONG 0x14 13. "   ARVALID1    , " "0    ,1    "
      BITFLD.LONG 0x14 14. "   AWREADY1    , " "0    ,1    "
      BITFLD.LONG 0x14 15. "   AWVALID1    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 16. "   BVALID2     , " "0    ,1    "
      BITFLD.LONG 0x14 17. "   RVALID2     , " "0    ,1    "
      BITFLD.LONG 0x14 18. "   WREADY2     , " "0    ,1    "
      BITFLD.LONG 0x14 19. "   WVALID2     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 20. "   ARREADY2    , " "0    ,1    "
      BITFLD.LONG 0x14 21. "   ARVALID2    , " "0    ,1    "
      BITFLD.LONG 0x14 22. "   AWREADY2    , " "0    ,1    "
      BITFLD.LONG 0x14 23. "   AWVALID2    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 24. "   BVALID3     , " "0    ,1    "
      BITFLD.LONG 0x14 25. "   RVALID3     , " "0    ,1    "
      BITFLD.LONG 0x14 26. "   WREADY3     , " "0    ,1    "
      BITFLD.LONG 0x14 27. "   WVALID3     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 28. "   ARREADY3    , " "0    ,1    "
      BITFLD.LONG 0x14 29. "   ARVALID3    , " "0    ,1    "
      BITFLD.LONG 0x14 30. "   AWREADY3    , " "0    ,1    "
      BITFLD.LONG 0x14 31. "   AWVALID3    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "PUB @ chain_bus_status1 RO"
;-------------------------------------------------
    VARX 0x18 %l DBUS.read(0x00040006)
    TEXTLINE ""
    LINE.LONG 0x18 "chain_bus_status1,chain_bus_status1"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x18 0. "   BVALID4     , " "0    ,1    "
      BITFLD.LONG 0x18 1. "   RVALID4     , " "0    ,1    "
      BITFLD.LONG 0x18 2. "   WREADY4     , " "0    ,1    "
      BITFLD.LONG 0x18 3. "   WVALID4     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 4. "   ARREADY4    , " "0    ,1    "
      BITFLD.LONG 0x18 5. "   ARVALID4    , " "0    ,1    "
      BITFLD.LONG 0x18 6. "   AWREADY4    , " "0    ,1    "
      BITFLD.LONG 0x18 7. "   AWVALID4    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 8. "   BVALID5     , " "0    ,1    "
      BITFLD.LONG 0x18 9. "   RVALID5     , " "0    ,1    "
      BITFLD.LONG 0x18 10. "   WREADY5     , " "0    ,1    "
      BITFLD.LONG 0x18 11. "   WVALID5     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 12. "   ARREADY5    , " "0    ,1    "
      BITFLD.LONG 0x18 13. "   ARVALID5    , " "0    ,1    "
      BITFLD.LONG 0x18 14. "   AWREADY5    , " "0    ,1    "
      BITFLD.LONG 0x18 15. "   AWVALID5    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 16. "   BVALID6     , " "0    ,1    "
      BITFLD.LONG 0x18 17. "   RVALID6     , " "0    ,1    "
      BITFLD.LONG 0x18 18. "   WREADY6     , " "0    ,1    "
      BITFLD.LONG 0x18 19. "   WVALID6     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 20. "   ARREADY6    , " "0    ,1    "
      BITFLD.LONG 0x18 21. "   ARVALID6    , " "0    ,1    "
      BITFLD.LONG 0x18 22. "   AWREADY6    , " "0    ,1    "
      BITFLD.LONG 0x18 23. "   AWVALID6    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 24. "   BVALID7     , " "0    ,1    "
      BITFLD.LONG 0x18 25. "   RVALID7     , " "0    ,1    "
      BITFLD.LONG 0x18 26. "   WREADY7     , " "0    ,1    "
      BITFLD.LONG 0x18 27. "   WVALID7     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 28. "   ARREADY7    , " "0    ,1    "
      BITFLD.LONG 0x18 29. "   ARVALID7    , " "0    ,1    "
      BITFLD.LONG 0x18 30. "   AWREADY7    , " "0    ,1    "
      BITFLD.LONG 0x18 31. "   AWVALID7    , " "0    ,1    "
    TEXTLINE ""
TREE.END
;###################Tree###################
TREE "WTLCP"
    SGROUP "WTLCP @ chain_lp_dbg1 RO"
;-------------------------------------------------
    VARX 0x04 %l DBUS.read(0x00050000)
    TEXTLINE ""
    LINE.LONG 0x04 "chain_lp_dbg1,chain_lp_dbg1"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x04 0. "   int_req_busmon0      , " "0    ,1    "
      BITFLD.LONG 0x04 1. "   int_req_busmon1       , " "0    ,1    "
      BITFLD.LONG 0x04 2. "   int_req_busmon2       , " "0    ,1    "
      BITFLD.LONG 0x04 3. "   int_req_busmon3        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 4. "   int_req_busmon4      , " "0    ,1    "
      BITFLD.LONG 0x04 5. "   int_req_busmon5       , " "0    ,1    "
      BITFLD.LONG 0x04 6. "   int_req_busmon6       , " "0    ,1    "
      BITFLD.LONG 0x04 7. "   int_req_busmon7        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 8. "   reseved              , " "0    ,1    "
      BITFLD.LONG 0x04 9. "   pmu_cevaxs_rst_n      , " "0    ,1    "
      BITFLD.LONG 0x04 10. "   pmu_tg_cevax_rst_n    , " "0    ,1    "
      BITFLD.LONG 0x04 11. "   pmu_lte_cevax_rst_n    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 12. "   tg_ceva_rst_out_n    , " "0    ,1    "
      BITFLD.LONG 0x04 13. "   lte_ceva_rst_out_n    , " "0    ,1    "
      BITFLD.LONG 0x04 14. "   ceva_ocm_core1_rst    , " "0    ,1    "
      BITFLD.LONG 0x04 15. "   ceva_ocm_core0_rst     , " "0    ,1    "
    TEXTLINE ""
    SGROUP "WTLCP @ chain_lp_dbg2 RO"
;-------------------------------------------------
    VARX 0x08 %l DBUS.read(0x00050100)
    TEXTLINE ""
    LINE.LONG 0x08 "chain_lp_dbg2,chain_lp_dbg2"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x08 0. "   int_req_busmon8      , " "0    ,1    "
      BITFLD.LONG 0x08 1. "   int_req_busmon9        , " "0    ,1    "
      BITFLD.LONG 0x08 2. "   int_req_busmon10              , " "0    ,1    "
      BITFLD.LONG 0x08 3. "   int_req_busmon11              , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 4. "   int_req_busmon12     , " "0    ,1    "
      BITFLD.LONG 0x08 5. "   int_req_busmon13       , " "0    ,1    "
      BITFLD.LONG 0x08 6. "   int_req_busmon14              , " "0    ,1    "
      BITFLD.LONG 0x08 7. "   int_req_busmon15              , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 8. "   int_req_busmon16     , " "0    ,1    "
      BITFLD.LONG 0x08 9. "   int_req_busmon17       , " "0    ,1    "
      BITFLD.LONG 0x08 10. "   rst_noc_n_wtl_pub_dsp_sync    , " "0    ,1    "
      BITFLD.LONG 0x08 11. "   rst_noc_n_wtl_pub_4x1_sync    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 12. "   rst_mux4to1_n_dsp    , " "0    ,1    "
      BITFLD.LONG 0x08 13. "   rst_mux4to1_n_wcdma    , " "0    ,1    "
    SGROUP "WTLCP @ chain_lp_dbg3 RO"
;-------------------------------------------------
    VARX 0x0C %l DBUS.read(0x00050200)
    TEXTLINE ""
    LINE.LONG 0x0C "chain_lp_dbg3,chain_lp_dbg3"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x0C 0.--4. "   reseved                     , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x0C 5. "   wcdma_m5_access_en         , " "0    ,1    "
      BITFLD.LONG 0x0C 6. "   lacc2dsp_access_en           , " "0    ,1    "
      BITFLD.LONG 0x0C 7. "   pubcp2wtldsp_access_en      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 8. "   tl42x_psu_core_idle_r_tg    , " "0    ,1    "
      BITFLD.LONG 0x0C 9. "   tl42x_psu_dsp_idle_r_tg    , " "0    ,1    "
      BITFLD.LONG 0x0C 10. "   tl42x_psu_core_idle_r_lte    , " "0    ,1    "
      BITFLD.LONG 0x0C 11. "   tl42x_psu_dsp_idle_r_lte    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 12. "   rst_dsp_cp_mtx_aon          , " "0    ,1    "
      BITFLD.LONG 0x0C 13. "   pmu_glob_rst_n             , " "0    ,1    "
      BITFLD.LONG 0x0C 14.--15. "   reseved                      , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg4 RO"
;-------------------------------------------------
    VARX 0x10 %l DBUS.read(0x00050300)
    TEXTLINE ""
    LINE.LONG 0x10 "chain_lp_dbg4,chain_lp_dbg4"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x10 0. "   lp_stat_dsp_cp_matrix_main    , " "0    ,1    "
      BITFLD.LONG 0x10 1. "   lp_stat_dsp_cp_matrix_s8    , " "0    ,1    "
      BITFLD.LONG 0x10 2. "   lp_stat_dsp_cp_matrix_s7    , " "0    ,1    "
      BITFLD.LONG 0x10 3. "   lp_stat_dsp_cp_matrix_s6    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 4. "   lp_stat_dsp_cp_matrix_s5      , " "0    ,1    "
      BITFLD.LONG 0x10 5. "   lp_stat_dsp_cp_matrix_s4    , " "0    ,1    "
      BITFLD.LONG 0x10 6. "   lp_stat_dsp_cp_matrix_s3    , " "0    ,1    "
      BITFLD.LONG 0x10 7. "   lp_stat_dsp_cp_matrix_s2    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 8. "   lp_stat_dsp_cp_matrix_s1      , " "0    ,1    "
      BITFLD.LONG 0x10 9. "   lp_stat_dsp_cp_matrix_s0    , " "0    ,1    "
      BITFLD.LONG 0x10 10. "   lp_stat_dsp_cp_matrix_m7    , " "0    ,1    "
      BITFLD.LONG 0x10 11. "   lp_stat_dsp_cp_matrix_m6    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 12. "   lp_stat_dsp_cp_matrix_m5      , " "0    ,1    "
      BITFLD.LONG 0x10 13. "   lp_stat_dsp_cp_matrix_m4    , " "0    ,1    "
      BITFLD.LONG 0x10 14. "   lp_stat_dsp_cp_matrix_m3    , " "0    ,1    "
      BITFLD.LONG 0x10 15. "   lp_stat_dsp_cp_matrix_m2    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 16. "   lp_stat_dsp_cp_matrix_m1      , " "0    ,1    "
      BITFLD.LONG 0x10 17. "   lp_stat_dsp_cp_matrix_m0    , " "0    ,1    "
    SGROUP "WTLCP @ chain_lp_dbg5 RO"
;-------------------------------------------------
    VARX 0x14 %l DBUS.read(0x00050400)
    TEXTLINE ""
    LINE.LONG 0x14 "chain_lp_dbg5,chain_lp_dbg5"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x14 0. "   axi_busy_hu3ge_b          , " "0    ,1    "
      BITFLD.LONG 0x14 1. "   axi_busy_hu3ge_a          , " "0    ,1    "
      BITFLD.LONG 0x14 2. "   wcdma_mtx_s0_stop         , " "0    ,1    "
      BITFLD.LONG 0x14 3. "   wcdma_slp_req_m0          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 4. "   wcdma_slp_req_m1          , " "0    ,1    "
      BITFLD.LONG 0x14 5. "   wcdma_slp_req_m2          , " "0    ,1    "
      BITFLD.LONG 0x14 6. "   wcdma_slp_req_m3          , " "0    ,1    "
      BITFLD.LONG 0x14 7. "   wcdma_slp_req_main        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 8. "   lp_stat_acc2ddr_mtx_s0    , " "0    ,1    "
      BITFLD.LONG 0x14 9. "   lp_stat_acc2ddr_mtx_m4    , " "0    ,1    "
      BITFLD.LONG 0x14 10. "   lp_stat_acc2ddr_mtx_m3    , " "0    ,1    "
      BITFLD.LONG 0x14 11. "   lp_stat_acc2ddr_mtx_m2    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 12. "   lp_stat_acc2ddr_mtx_m1    , " "0    ,1    "
      BITFLD.LONG 0x14 13. "   lp_stat_acc2ddr_mtx_m0    , " "0    ,1    "
      BITFLD.LONG 0x14 14.--15. "   reseved                   , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg6 RO"
;-------------------------------------------------
    VARX 0x18 %l DBUS.read(0x00050600)
    TEXTLINE ""
    LINE.LONG 0x18 "chain_lp_dbg6,chain_lp_dbg6"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x18 0. "   cgm_dsp_apb_en       , " "0    ,1    "
      BITFLD.LONG 0x18 1. "   cgm_dsp_ahb_en      , " "0    ,1    "
      BITFLD.LONG 0x18 2. "   cgm_dsp_axi_en        , " "0    ,1    "
      BITFLD.LONG 0x18 3. "   reseved                , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 4. "   clk_apb_en           , " "0    ,1    "
      BITFLD.LONG 0x18 5. "   clk_ahb_en          , " "0    ,1    "
      BITFLD.LONG 0x18 6. "   clk_axi_en            , " "0    ,1    "
      BITFLD.LONG 0x18 7. "   reseved                , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 8. "   tg_ceva_clk_en       , " "0    ,1    "
      BITFLD.LONG 0x18 9. "   lte_ceva_clk_en     , " "0    ,1    "
      BITFLD.LONG 0x18 10. "   clk_tg_dsp_core_en    , " "0    ,1    "
      BITFLD.LONG 0x18 11. "   clk_lte_dsp_core_en    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 12. "   cgm_tgdsp_core_en    , " "0    ,1    "
      BITFLD.LONG 0x18 13. "   cgm_ldsp_core_en    , " "0    ,1    "
      BITFLD.LONG 0x18 14.--15. "   reseved               , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg7 RO"
;-------------------------------------------------
    VARX 0x1C %l DBUS.read(0x00050900)
    TEXTLINE ""
    LINE.LONG 0x1C "chain_lp_dbg7,chain_lp_dbg7"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x1C 0. "   wcdma_top_pub0_light_sleep    , " "0    ,1    "
      BITFLD.LONG 0x1C 1. "   wcdma_top_doze_stop    , " "0    ,1    "
      BITFLD.LONG 0x1C 2. "   wcdma_top_pub0_deep_sleep    , " "0    ,1    "
      BITFLD.LONG 0x1C 3. "   wcdma_top_deep_sleep     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 4. "   wcdma_mtx_s0_stop             , " "0    ,1    "
      BITFLD.LONG 0x1C 5. "   wtlcp_pub_deep_stop    , " "0    ,1    "
      BITFLD.LONG 0x1C 6. "   wtlcp_doze_top               , " "0    ,1    "
      BITFLD.LONG 0x1C 7. "   wtlcp_deep_stop_final    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 8. "   wtlcp_deep_stop               , " "0    ,1    "
      BITFLD.LONG 0x1C 9. "   wtlcp_light_stop       , " "0    ,1    "
      BITFLD.LONG 0x1C 10. "   wtlcp_tgdsp_core_stop        , " "0    ,1    "
      BITFLD.LONG 0x1C 11. "   wtlcp_ldsp_core_stop     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 12. "   tg_dma_busy                   , " "0    ,1    "
      BITFLD.LONG 0x1C 13. "   lte_dma_busy           , " "0    ,1    "
      BITFLD.LONG 0x1C 14. "   tg_dma_stop                  , " "0    ,1    "
      BITFLD.LONG 0x1C 15. "   lte_dma_stop             , " "0    ,1    "
    TEXTLINE ""
    SGROUP "WTLCP @ chain_lp_dbg8 RO"
;-------------------------------------------------
    VARX 0x20 %l DBUS.read(0x00050A00)
    TEXTLINE ""
    LINE.LONG 0x20 "chain_lp_dbg8,chain_lp_dbg8"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x20 0. "   tg_dsp_core_slp_and_stop    , " "0    ,1    "
      BITFLD.LONG 0x20 1. "   lte_dsp_core_slp_and_stop    , " "0    ,1    "
      BITFLD.LONG 0x20 2. "   tg_dsp_core_sleep    , " "0    ,1    "
      BITFLD.LONG 0x20 3. "   lte_dsp_core_sleep    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 4. "   lte_proc_stop               , " "0    ,1    "
      BITFLD.LONG 0x20 5. "   dsp_mtx_stop                 , " "0    ,1    "
      BITFLD.LONG 0x20 6. "   lte_deep_sleep       , " "0    ,1    "
      BITFLD.LONG 0x20 7. "   lte_doze_sleep        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 8. "   lte_pub_light_sleep         , " "0    ,1    "
      BITFLD.LONG 0x20 9. "   lte_pub_deep_sleep           , " "0    ,1    "
      BITFLD.LONG 0x20 10.--31. "   reseved              , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg9 RO"
;-------------------------------------------------
    VARX 0x24 %l DBUS.read(0x00050B00)
    TEXTLINE ""
    LINE.LONG 0x24 "chain_lp_dbg9,chain_lp_dbg9"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x24 0. "   icu_vint_r_tg_dsp    , " "0    ,1    "
      BITFLD.LONG 0x24 1. "   icu_nmi_tg_dsp        , " "0    ,1    "
      BITFLD.LONG 0x24 2. "   icu_int2_tg_dsp    , " "0    ,1    "
      BITFLD.LONG 0x24 3. "   icu_int1_tg_dsp     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x24 4. "   icu_int0_tg_dsp      , " "0    ,1    "
      BITFLD.LONG 0x24 5. "   icu_vint_r_lte_dsp    , " "0    ,1    "
      BITFLD.LONG 0x24 6. "   icu_nmi_lte_dsp    , " "0    ,1    "
      BITFLD.LONG 0x24 7. "   icu_int2_lte_dsp    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x24 8. "   icu_int1_lte_dsp     , " "0    ,1    "
      BITFLD.LONG 0x24 9. "   icu_int0_lte_dsp      , " "0    ,1    "
      BITFLD.LONG 0x24 10.--15. "   reseved            , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg10 RO"
;-------------------------------------------------
    VARX 0x28 %l DBUS.read(0x00050C00)
    TEXTLINE ""
    LINE.LONG 0x28 "chain_lp_dbg10,chain_lp_dbg10"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x28 0. "   gsm_rfctrl_val[15]    , " "0    ,1    "
      BITFLD.LONG 0x28 1. "   td_rfctrl_val[15]    , " "0    ,1    "
      BITFLD.LONG 0x28 2. "   wcdma_rfctrl[15]    , " "0    ,1    "
      BITFLD.LONG 0x28 3.--15. "   reseved    , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
    TEXTLINE ""
    SGROUP "WTLCP @ chain_lp_dbg11 RO"
;-------------------------------------------------
    VARX 0x2C %l DBUS.read(0x00050D00)
    TEXTLINE ""
    LINE.LONG 0x2C "chain_lp_dbg11,chain_lp_dbg11"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x2C 0.--2. "   reseved                  , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x2C 3. "   pcp_wcdma_slp_int    , " "0    ,1    "
      BITFLD.LONG 0x2C 4. "   timer1_out_r_lte      , " "0    ,1    "
      BITFLD.LONG 0x2C 5. "   timer0_out_r_lte       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x2C 6. "   int_req_syst_lte         , " "0    ,1    "
      BITFLD.LONG 0x2C 7. "   int_req_wdg_lte      , " "0    ,1    "
      BITFLD.LONG 0x2C 8. "   ceva_wcdma_slp_int    , " "0    ,1    "
      BITFLD.LONG 0x2C 9. "   rft_wake_clkdsp_int    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x2C 10. "   timer1_out_r_tg          , " "0    ,1    "
      BITFLD.LONG 0x2C 11. "   timer0_out_r_tg      , " "0    ,1    "
      BITFLD.LONG 0x2C 12. "   int_req_syst_tg       , " "0    ,1    "
      BITFLD.LONG 0x2C 13. "   int_req_wdg_tg         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x2C 14. "   tmr_wake_clkdsp_level    , " "0    ,1    "
      BITFLD.LONG 0x2C 15. "   stc_fc_int           , " "0    ,1    "
    SGROUP "WTLCP @ chain_lp_dbg12 RO"
;-------------------------------------------------
    VARX 0x30 %l DBUS.read(0x00050E00)
    TEXTLINE ""
    LINE.LONG 0x30 "chain_lp_dbg12,chain_lp_dbg12"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x30 0. "   rft_autopd_xtl_en        , " "0    ,1    "
      BITFLD.LONG 0x30 1. "   rft_tmr_autopd_xtl_en    , " "0    ,1    "
      BITFLD.LONG 0x30 2. "   wcdma_power_en[0]        , " "0    ,1    "
      BITFLD.LONG 0x30 3. "   wcdma_power_en[1]        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x30 4. "   stc_tmr_autopd_xtl_en    , " "0    ,1    "
      BITFLD.LONG 0x30 5. "   wakeup_xtl_en_4g_lte     , " "0    ,1    "
      BITFLD.LONG 0x30 6. "   wakeup_xtl_en_3g_td      , " "0    ,1    "
      BITFLD.LONG 0x30 7. "   wakeup_xtl_en_3g_w       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x30 8. "   wakeup_xtl_en_2g         , " "0    ,1    "
      BITFLD.LONG 0x30 9. "   pubcp_wakeup_int         , " "0    ,1    "
      BITFLD.LONG 0x30 10. "   lte_dsp_wakeup_int       , " "0    ,1    "
      BITFLD.LONG 0x30 11. "   tg_dsp_wakeup_int        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x30 12. "   wcdma_top_deep_sleep     , " "0    ,1    "
      BITFLD.LONG 0x30 13. "   lte_deep_sleep           , " "0    ,1    "
      BITFLD.LONG 0x30 14. "   wtlcp_tgdsp_core_stop    , " "0    ,1    "
      BITFLD.LONG 0x30 15. "   wtlcp_ldsp_core_stop     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x30 16. "   dsp_mtx_stop             , " "0    ,1    "
      BITFLD.LONG 0x30 17. "   dsp_deep_sleep_en        , " "0    ,1    "
      BITFLD.LONG 0x30 18. "   wtlcp_deep_stop          , " "0    ,1    "
      BITFLD.LONG 0x30 19. "   wtlcp_deep_stop_final    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x30 20.--31. "   reseved                  , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg13 RO"
;-------------------------------------------------
    VARX 0x34 %l DBUS.read(0x00050F00)
    TEXTLINE ""
    LINE.LONG 0x34 "chain_lp_dbg13,chain_lp_dbg13"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x34 0. "   cgm_buusy_245_76m_lte    , " "0    ,1    "
      BITFLD.LONG 0x34 1. "   cgm_busy_102_4m_lte    , " "0    ,1    "
      BITFLD.LONG 0x34 2. "   cgm_busy_204_8m_lte    , " "0    ,1    "
      BITFLD.LONG 0x34 3. "   cgm_busy_153_6m_lte    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x34 4. "   cgm_busy_51_2m           , " "0    ,1    "
      BITFLD.LONG 0x34 5. "   cgm_busy_76_8m         , " "0    ,1    "
      BITFLD.LONG 0x34 6. "   cgm_busy_153_6m        , " "0    ,1    "
      BITFLD.LONG 0x34 7. "   cgm_busy_48m           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x34 8. "   cgm_busy_96m             , " "0    ,1    "
      BITFLD.LONG 0x34 9. "   cgm_busy_307_2m        , " "0    ,1    "
      BITFLD.LONG 0x34 10. "   cgm_busy_384m          , " "0    ,1    "
      BITFLD.LONG 0x34 11. "   cgm_busy_64m           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x34 12. "   cgm_busy_128m            , " "0    ,1    "
      BITFLD.LONG 0x34 13. "   cgm_busy_256m          , " "0    ,1    "
      BITFLD.LONG 0x34 14. "   cgm_busy_512m          , " "0    ,1    "
      BITFLD.LONG 0x34 15. "   cgm_busy_26m_rf0       , " "0    ,1    "
    TEXTLINE ""
    SGROUP "WTLCP @ chain_lp_dbg14 RO"
;-------------------------------------------------
    VARX 0x38 %l DBUS.read(0x00051000)
    TEXTLINE ""
    LINE.LONG 0x38 "chain_lp_dbg14,chain_lp_dbg14"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x38 0.--2. "   mtx_ce_m1_c_stat       , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x38 3.--5. "   mtx_ce_m0_c_stat       , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x38 6.--8. "   brg_ulch_ahb_c_stat     , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x38 9.--11. "   brg_dpfec_s1_c_stat    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    TEXTLINE ""
      BITFLD.LONG 0x38 12.--14. "   brg_dpfec_s0_c_stat    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x38 15.--17. "   brg_dpfec_m0_c_stat    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x38 18.--20. "   brg_csdfe_ahb_c_stat    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x38 21.--23. "   brg_ce_s1_c_stat       , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    TEXTLINE ""
      BITFLD.LONG 0x38 24.--26. "   brg_ce_m0_c_stat       , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x38 27.--29. "   brg_ce_s0_c_stat       , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x38 30.--31. "   reseved                 , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg15 RO"
;-------------------------------------------------
    VARX 0x3C %l DBUS.read(0x00051100)
    TEXTLINE ""
    LINE.LONG 0x3C "chain_lp_dbg15,chain_lp_dbg15"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x3C 0.--2. "   mtx_top_m3_c_stat      , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x3C 3.--5. "   mtx_top_m2_c_stat      , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x3C 6.--8. "   mtx_top_m1_c_stat      , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x3C 9.--11. "   mtx_top_m0_c_stat      , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    TEXTLINE ""
      BITFLD.LONG 0x3C 12.--14. "   mtx_csdfe_s0_c_stat    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x3C 15.--17. "   mtx_csdfe_m2_c_stat    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x3C 18.--20. "   mtx_csdfe_m1_c_stat    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x3C 21.--23. "   mtx_csdfe_m0_c_stat    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    TEXTLINE ""
      BITFLD.LONG 0x3C 24.--26. "   mtx_ce_s0_c_stat       , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x3C 27.--29. "   mtx_ce_m3_c_stat       , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x3C 30.--31. "   reseved                , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg16 RO"
;-------------------------------------------------
    VARX 0x40 %l DBUS.read(0x00051200)
    TEXTLINE ""
    LINE.LONG 0x40 "chain_lp_dbg16,chain_lp_dbg16"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x40 0.--2. "   mtx_top_s8_c_stat    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x40 3.--5. "   mtx_top_s6_c_stat    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x40 6.--8. "   mtx_top_s2_c_stat    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x40 9.--11. "   mtx_top_s7_c_stat      , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    TEXTLINE ""
      BITFLD.LONG 0x40 12.--14. "   mtx_top_s4_c_stat    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x40 15.--17. "   mtx_top_s1_c_stat    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x40 18.--20. "   mtx_top_s0_c_stat    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x40 21.--23. "   mtx_top_main_c_stat    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    TEXTLINE ""
      BITFLD.LONG 0x40 24.--26. "   mtx_top_m5_stat      , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x40 27.--29. "   mtx_top_m4_stat      , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x40 30.--31. "   reseved              , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg17 RO"
;-------------------------------------------------
    VARX 0x44 %l DBUS.read(0x00051300)
    TEXTLINE ""
    LINE.LONG 0x44 "chain_lp_dbg17,chain_lp_dbg17"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x44 0.--2. "   mtx_top_s9_c_stat[2:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x44 3.--31. "   reseved    , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg18 RO"
;-------------------------------------------------
    VARX 0x48 %l DBUS.read(0x00052000)
    TEXTLINE ""
    LINE.LONG 0x48 "chain_lp_dbg18,chain_lp_dbg18"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x48 0. "   clk_dsp_matrix_m0_out    , " "0    ,1    "
      BITFLD.LONG 0x48 1. "   csysack_dsp_cp_matrix_m0    , " "0    ,1    "
      BITFLD.LONG 0x48 2. "   csysreq_dsp_cp_matrix_m0    , " "0    ,1    "
      BITFLD.LONG 0x48 3. "   cactive_dsp_cp_matrix_m0    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x48 4. "   clk_dsp_matrix_m1_out    , " "0    ,1    "
      BITFLD.LONG 0x48 5. "   csysack_dsp_cp_matrix_m1    , " "0    ,1    "
      BITFLD.LONG 0x48 6. "   csysreq_dsp_cp_matrix_m1    , " "0    ,1    "
      BITFLD.LONG 0x48 7. "   cactive_dsp_cp_matrix_m1    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x48 8. "   clk_dsp_matrix_m2_out    , " "0    ,1    "
      BITFLD.LONG 0x48 9. "   csysack_dsp_cp_matrix_m2    , " "0    ,1    "
      BITFLD.LONG 0x48 10. "   csysreq_dsp_cp_matrix_m2    , " "0    ,1    "
      BITFLD.LONG 0x48 11. "   cactive_dsp_cp_matrix_m2    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x48 12. "   clk_dsp_matrix_m3_out    , " "0    ,1    "
      BITFLD.LONG 0x48 13. "   csysack_dsp_cp_matrix_m3    , " "0    ,1    "
      BITFLD.LONG 0x48 14. "   csysreq_dsp_cp_matrix_m3    , " "0    ,1    "
      BITFLD.LONG 0x48 15. "   cactive_dsp_cp_matrix_m3    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x48 16. "   clk_dsp_matrix_m4_out    , " "0    ,1    "
      BITFLD.LONG 0x48 17. "   csysack_dsp_cp_matrix_m4    , " "0    ,1    "
      BITFLD.LONG 0x48 18. "   csysreq_dsp_cp_matrix_m4    , " "0    ,1    "
      BITFLD.LONG 0x48 19. "   cactive_dsp_cp_matrix_m4    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x48 20. "   clk_dsp_matrix_m5_out    , " "0    ,1    "
      BITFLD.LONG 0x48 21. "   csysack_dsp_cp_matrix_m5    , " "0    ,1    "
      BITFLD.LONG 0x48 22. "   csysreq_dsp_cp_matrix_m5    , " "0    ,1    "
      BITFLD.LONG 0x48 23. "   cactive_dsp_cp_matrix_m5    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x48 24. "   clk_dsp_matrix_m6_out    , " "0    ,1    "
      BITFLD.LONG 0x48 25. "   csysack_dsp_cp_matrix_m6    , " "0    ,1    "
      BITFLD.LONG 0x48 26. "   csysreq_dsp_cp_matrix_m6    , " "0    ,1    "
      BITFLD.LONG 0x48 27. "   cactive_dsp_cp_matrix_m6    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x48 28. "   clk_dsp_matrix_m7_out    , " "0    ,1    "
      BITFLD.LONG 0x48 29. "   csysack_dsp_cp_matrix_m7    , " "0    ,1    "
      BITFLD.LONG 0x48 30. "   csysreq_dsp_cp_matrix_m7    , " "0    ,1    "
      BITFLD.LONG 0x48 31. "   cactive_dsp_cp_matrix_m7    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "WTLCP @ chain_lp_dbg19 RO"
;-------------------------------------------------
    VARX 0x4C %l DBUS.read(0x00052100)
    TEXTLINE ""
    LINE.LONG 0x4C "chain_lp_dbg19,chain_lp_dbg19"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x4C 0. "   clk_dsp_matrix_s0_out    , " "0    ,1    "
      BITFLD.LONG 0x4C 1. "   csysack_dsp_cp_matrix_s0    , " "0    ,1    "
      BITFLD.LONG 0x4C 2. "   csysreq_dsp_cp_matrix_s0    , " "0    ,1    "
      BITFLD.LONG 0x4C 3. "   cactive_dsp_cp_matrix_s0    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x4C 4. "   clk_dsp_matrix_s1_out    , " "0    ,1    "
      BITFLD.LONG 0x4C 5. "   csysack_dsp_cp_matrix_s1    , " "0    ,1    "
      BITFLD.LONG 0x4C 6. "   csysreq_dsp_cp_matrix_s1    , " "0    ,1    "
      BITFLD.LONG 0x4C 7. "   cactive_dsp_cp_matrix_s1    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x4C 8. "   clk_dsp_matrix_s2_out    , " "0    ,1    "
      BITFLD.LONG 0x4C 9. "   csysack_dsp_cp_matrix_s2    , " "0    ,1    "
      BITFLD.LONG 0x4C 10. "   csysreq_dsp_cp_matrix_s2    , " "0    ,1    "
      BITFLD.LONG 0x4C 11. "   cactive_dsp_cp_matrix_s2    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x4C 12. "   clk_dsp_matrix_s3_out    , " "0    ,1    "
      BITFLD.LONG 0x4C 13. "   csysack_dsp_cp_matrix_s3    , " "0    ,1    "
      BITFLD.LONG 0x4C 14. "   csysreq_dsp_cp_matrix_s3    , " "0    ,1    "
      BITFLD.LONG 0x4C 15. "   cactive_dsp_cp_matrix_s3    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x4C 16. "   clk_dsp_matrix_s4_out    , " "0    ,1    "
      BITFLD.LONG 0x4C 17. "   csysack_dsp_cp_matrix_s4    , " "0    ,1    "
      BITFLD.LONG 0x4C 18. "   csysreq_dsp_cp_matrix_s4    , " "0    ,1    "
      BITFLD.LONG 0x4C 19. "   cactive_dsp_cp_matrix_s4    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x4C 20. "   clk_dsp_matrix_s5_out    , " "0    ,1    "
      BITFLD.LONG 0x4C 21. "   csysack_dsp_cp_matrix_s5    , " "0    ,1    "
      BITFLD.LONG 0x4C 22. "   csysreq_dsp_cp_matrix_s5    , " "0    ,1    "
      BITFLD.LONG 0x4C 23. "   cactive_dsp_cp_matrix_s5    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x4C 24. "   clk_dsp_matrix_s6_out    , " "0    ,1    "
      BITFLD.LONG 0x4C 25. "   csysack_dsp_cp_matrix_s6    , " "0    ,1    "
      BITFLD.LONG 0x4C 26. "   csysreq_dsp_cp_matrix_s6    , " "0    ,1    "
      BITFLD.LONG 0x4C 27. "   cactive_dsp_cp_matrix_s6    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x4C 28. "   clk_dsp_matrix_s7_out    , " "0    ,1    "
      BITFLD.LONG 0x4C 29. "   csysack_dsp_cp_matrix_s7    , " "0    ,1    "
      BITFLD.LONG 0x4C 30. "   csysreq_dsp_cp_matrix_s7    , " "0    ,1    "
      BITFLD.LONG 0x4C 31. "   cactive_dsp_cp_matrix_s7    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "WTLCP @ chain_lp_dbg20 RO"
;-------------------------------------------------
    VARX 0x50 %l DBUS.read(0x00052200)
    TEXTLINE ""
    LINE.LONG 0x50 "chain_lp_dbg20,chain_lp_dbg20"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x50 0. "   clk_dsp_matrix_s8_out      , " "0    ,1    "
      BITFLD.LONG 0x50 1. "   csysack_dsp_cp_matrix_s8      , " "0    ,1    "
      BITFLD.LONG 0x50 2. "   csysreq_dsp_cp_matrix_s8      , " "0    ,1    "
      BITFLD.LONG 0x50 3. "   cactive_dsp_cp_matrix_s8      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x50 4. "   clk_dsp_matrix_main_out    , " "0    ,1    "
      BITFLD.LONG 0x50 5. "   csysack_dsp_cp_matrix_main    , " "0    ,1    "
      BITFLD.LONG 0x50 6. "   csysreq_dsp_cp_matrix_main    , " "0    ,1    "
      BITFLD.LONG 0x50 7. "   cactive_dsp_cp_matrix_main    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x50 8.--31. "   reseved                    , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg21 RO"
;-------------------------------------------------
    VARX 0x54 %l DBUS.read(0x00052300)
    TEXTLINE ""
    LINE.LONG 0x54 "chain_lp_dbg21,chain_lp_dbg21"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x54 0. "   lp_stat_dsp_cp_matrix_s0    , " "0    ,1    "
      BITFLD.LONG 0x54 1. "   lp_stat_dsp_cp_matrix_s1      , " "0    ,1    "
      BITFLD.LONG 0x54 2. "   lp_stat_dsp_cp_matrix_s2    , " "0    ,1    "
      BITFLD.LONG 0x54 3. "   lp_stat_dsp_cp_matrix_s3    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x54 4. "   lp_stat_dsp_cp_matrix_s4    , " "0    ,1    "
      BITFLD.LONG 0x54 5. "   lp_stat_dsp_cp_matrix_s5      , " "0    ,1    "
      BITFLD.LONG 0x54 6. "   lp_stat_dsp_cp_matrix_s6    , " "0    ,1    "
      BITFLD.LONG 0x54 7. "   lp_stat_dsp_cp_matrix_s7    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x54 8. "   lp_stat_dsp_cp_matrix_s8    , " "0    ,1    "
      BITFLD.LONG 0x54 9. "   lp_stat_dsp_cp_matrix_main    , " "0    ,1    "
      BITFLD.LONG 0x54 10. "   lp_stat_dsp_cp_matrix_m0    , " "0    ,1    "
      BITFLD.LONG 0x54 11. "   lp_stat_dsp_cp_matrix_m1    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x54 12. "   lp_stat_dsp_cp_matrix_m2    , " "0    ,1    "
      BITFLD.LONG 0x54 13. "   lp_stat_dsp_cp_matrix_m3      , " "0    ,1    "
      BITFLD.LONG 0x54 14. "   lp_stat_dsp_cp_matrix_m4    , " "0    ,1    "
      BITFLD.LONG 0x54 15. "   lp_stat_dsp_cp_matrix_m5    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x54 16. "   lp_stat_dsp_cp_matrix_m6    , " "0    ,1    "
      BITFLD.LONG 0x54 17. "   lp_stat_dsp_cp_matrix_m7      , " "0    ,1    "
      BITFLD.LONG 0x54 18.--31. "   reseved                     , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg22 RO"
;-------------------------------------------------
    VARX 0x58 %l DBUS.read(0x00052400)
    TEXTLINE ""
    LINE.LONG 0x58 "chain_lp_dbg22,chain_lp_dbg22"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x58 0. "   clk_acc2ddr_mux4to1_mtx_m0_out    , " "0    ,1    "
      BITFLD.LONG 0x58 1. "   csysack_acc2ddr_mux4to1_mtx_m0    , " "0    ,1    "
      BITFLD.LONG 0x58 2. "   csysreq_acc2ddr_mux4to1_mtx_m0    , " "0    ,1    "
      BITFLD.LONG 0x58 3. "   cactive_acc2ddr_mux4to1_mtx_m0    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x58 4. "   clk_acc2ddr_mux4to1_mtx_m1_out    , " "0    ,1    "
      BITFLD.LONG 0x58 5. "   csysack_acc2ddr_mux4to1_mtx_m1    , " "0    ,1    "
      BITFLD.LONG 0x58 6. "   csysreq_acc2ddr_mux4to1_mtx_m1    , " "0    ,1    "
      BITFLD.LONG 0x58 7. "   cactive_acc2ddr_mux4to1_mtx_m1    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x58 8. "   clk_acc2ddr_mux4to1_mtx_m2_out    , " "0    ,1    "
      BITFLD.LONG 0x58 9. "   csysack_acc2ddr_mux4to1_mtx_m2    , " "0    ,1    "
      BITFLD.LONG 0x58 10. "   csysreq_acc2ddr_mux4to1_mtx_m2    , " "0    ,1    "
      BITFLD.LONG 0x58 11. "   cactive_acc2ddr_mux4to1_mtx_m2    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x58 12. "   clk_acc2ddr_mux4to1_mtx_m3_out    , " "0    ,1    "
      BITFLD.LONG 0x58 13. "   csysack_acc2ddr_mux4to1_mtx_m3    , " "0    ,1    "
      BITFLD.LONG 0x58 14. "   csysreq_acc2ddr_mux4to1_mtx_m3    , " "0    ,1    "
      BITFLD.LONG 0x58 15. "   cactive_acc2ddr_mux4to1_mtx_m3    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x58 16. "   clk_acc2ddr_mux4to1_mtx_m4_out    , " "0    ,1    "
      BITFLD.LONG 0x58 17. "   csysack_acc2ddr_mux4to1_mtx_m4    , " "0    ,1    "
      BITFLD.LONG 0x58 18. "   csysreq_acc2ddr_mux4to1_mtx_m4    , " "0    ,1    "
      BITFLD.LONG 0x58 19. "   cactive_acc2ddr_mux4to1_mtx_m4    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x58 20.--31. "   reseved                           , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg23 RO"
;-------------------------------------------------
    VARX 0x5C %l DBUS.read(0x00052500)
    TEXTLINE ""
    LINE.LONG 0x5C "chain_lp_dbg23,chain_lp_dbg23"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x5C 0. "   clk_acc2ddr_mux4to1_mtx_s0_out    , " "0    ,1    "
      BITFLD.LONG 0x5C 1. "   csysack_acc2ddr_mux4to1_mtx_s0    , " "0    ,1    "
      BITFLD.LONG 0x5C 2. "   csysreq_acc2ddr_mux4to1_mtx_s0    , " "0    ,1    "
      BITFLD.LONG 0x5C 3. "   cactive_acc2ddr_mux4to1_mtx_s0    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x5C 4.--31. "   reseved                           , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg24 RO"
;-------------------------------------------------
    VARX 0x60 %l DBUS.read(0x00052600)
    TEXTLINE ""
    LINE.LONG 0x60 "chain_lp_dbg24,chain_lp_dbg24"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x60 0. "   lp_stat_acc2ddr_mtx_m0    , " "0    ,1    "
      BITFLD.LONG 0x60 1. "   lp_stat_acc2ddr_mtx_m1    , " "0    ,1    "
      BITFLD.LONG 0x60 2. "   lp_stat_acc2ddr_mtx_m2    , " "0    ,1    "
      BITFLD.LONG 0x60 3. "   lp_stat_acc2ddr_mtx_m3    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x60 4. "   lp_stat_acc2ddr_mtx_m4    , " "0    ,1    "
      BITFLD.LONG 0x60 5. "   lp_stat_acc2ddr_mtx_m5    , " "0    ,1    "
      BITFLD.LONG 0x60 6.--31. "   reseved                   , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg25 RO"
;-------------------------------------------------
    VARX 0x64 %l DBUS.read(0x00052700)
    TEXTLINE ""
    LINE.LONG 0x64 "chain_lp_dbg25,chain_lp_dbg25"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x64 0. "   clk_wmtx_m0_out      , " "0    ,1    "
      BITFLD.LONG 0x64 1. "   csysack_cd_m0      , " "0    ,1    "
      BITFLD.LONG 0x64 2. "   csysreq_cd_m0      , " "0    ,1    "
      BITFLD.LONG 0x64 3. "   cactive_cd_m0      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x64 4. "   clk_wmtx_m1_out      , " "0    ,1    "
      BITFLD.LONG 0x64 5. "   csysack_cd_m1      , " "0    ,1    "
      BITFLD.LONG 0x64 6. "   csysreq_cd_m1      , " "0    ,1    "
      BITFLD.LONG 0x64 7. "   cactive_cd_m1      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x64 8. "   clk_wmtx_m2_out      , " "0    ,1    "
      BITFLD.LONG 0x64 9. "   csysack_cd_m2      , " "0    ,1    "
      BITFLD.LONG 0x64 10. "   csysreq_cd_m2      , " "0    ,1    "
      BITFLD.LONG 0x64 11. "   cactive_cd_m2      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x64 12. "   clk_wmtx_m3_out      , " "0    ,1    "
      BITFLD.LONG 0x64 13. "   csysack_cd_m3      , " "0    ,1    "
      BITFLD.LONG 0x64 14. "   csysreq_cd_m3      , " "0    ,1    "
      BITFLD.LONG 0x64 15. "   cactive_cd_m3      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x64 16. "   clk_wmtx_main_out    , " "0    ,1    "
      BITFLD.LONG 0x64 17. "   csysack_cd_main    , " "0    ,1    "
      BITFLD.LONG 0x64 18. "   csysreq_cd_main    , " "0    ,1    "
      BITFLD.LONG 0x64 19. "   cactive_cd_main    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x64 20.--31. "   reseved              , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg26 RO"
;-------------------------------------------------
    VARX 0x68 %l DBUS.read(0x00052800)
    TEXTLINE ""
    LINE.LONG 0x68 "chain_lp_dbg26,chain_lp_dbg26"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x68 0. "   clk_wmtx_s0_out    , " "0    ,1    "
      BITFLD.LONG 0x68 1. "   csysack_cd_s0    , " "0    ,1    "
      BITFLD.LONG 0x68 2. "   csysreq_cd_s0    , " "0    ,1    "
      BITFLD.LONG 0x68 3. "   cactive_cd_s0    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x68 4. "   clk_wmtx_s1_out    , " "0    ,1    "
      BITFLD.LONG 0x68 5. "   csysack_cd_s1    , " "0    ,1    "
      BITFLD.LONG 0x68 6. "   csysreq_cd_s1    , " "0    ,1    "
      BITFLD.LONG 0x68 7. "   cactive_cd_s1    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x68 8. "   clk_wmtx_s2_out    , " "0    ,1    "
      BITFLD.LONG 0x68 9. "   csysack_cd_s2    , " "0    ,1    "
      BITFLD.LONG 0x68 10. "   csysreq_cd_s2    , " "0    ,1    "
      BITFLD.LONG 0x68 11. "   cactive_cd_s2    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x68 12. "   clk_wmtx_s3_out    , " "0    ,1    "
      BITFLD.LONG 0x68 13. "   csysack_cd_s3    , " "0    ,1    "
      BITFLD.LONG 0x68 14. "   csysreq_cd_s3    , " "0    ,1    "
      BITFLD.LONG 0x68 15. "   cactive_cd_s3    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x68 16. "   clk_wmtx_s4_out    , " "0    ,1    "
      BITFLD.LONG 0x68 17. "   csysack_cd_s4    , " "0    ,1    "
      BITFLD.LONG 0x68 18. "   csysreq_cd_s4    , " "0    ,1    "
      BITFLD.LONG 0x68 19. "   cactive_cd_s4    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x68 20.--31. "   reseved            , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
    SGROUP "WTLCP @ chain_lp_dbg27 RO"
;-------------------------------------------------
    VARX 0x6C %l DBUS.read(0x00052900)
    TEXTLINE ""
    LINE.LONG 0x6C "chain_lp_dbg27,chain_lp_dbg27"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x6C 0. "   lp_wcdma_mtx_stat_s0    , " "0    ,1    "
      BITFLD.LONG 0x6C 1. "   lp_wcdma_mtx_stat_s1      , " "0    ,1    "
      BITFLD.LONG 0x6C 2. "   lp_wcdma_mtx_stat_s2    , " "0    ,1    "
      BITFLD.LONG 0x6C 3. "   lp_wcdma_mtx_stat_s3    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x6C 4. "   lp_wcdma_mtx_stat_s4    , " "0    ,1    "
      BITFLD.LONG 0x6C 5. "   lp_wcdma_mtx_stat_main    , " "0    ,1    "
      BITFLD.LONG 0x6C 6. "   lp_wcdma_mtx_mtat_m0    , " "0    ,1    "
      BITFLD.LONG 0x6C 7. "   lp_wcdma_mtx_mtat_m1    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x6C 8. "   lp_wcdma_mtx_mtat_m2    , " "0    ,1    "
      BITFLD.LONG 0x6C 9. "   lp_wcdma_mtx_mtat_m3      , " "0    ,1    "
      BITFLD.LONG 0x6C 10.--31. "   reseved                 , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
TREE.END
;###################Tree###################
TREE "PUBCP"
    SGROUP "PUBCP @ chain_lp_dbg_bus0 RO"
;-------------------------------------------------
    VARX 0x04 %l DBUS.read(0x00060100)
    TEXTLINE ""
    LINE.LONG 0x04 "chain_lp_dbg_bus0,chain_lp_dbg_bus0"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x04 0. "   csysack_cd_m7    , " "0    ,1    "
      BITFLD.LONG 0x04 1. "   csysreq_cd_m7    , " "0    ,1    "
      BITFLD.LONG 0x04 2. "   cactive_cd_m7    , " "0    ,1    "
      BITFLD.LONG 0x04 3. "   m7clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 4. "   csysack_cd_m6    , " "0    ,1    "
      BITFLD.LONG 0x04 5. "   csysreq_cd_m6    , " "0    ,1    "
      BITFLD.LONG 0x04 6. "   cactive_cd_m6    , " "0    ,1    "
      BITFLD.LONG 0x04 7. "   m6clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 8. "   csysack_cd_m5    , " "0    ,1    "
      BITFLD.LONG 0x04 9. "   csysreq_cd_m5    , " "0    ,1    "
      BITFLD.LONG 0x04 10. "   cactive_cd_m5    , " "0    ,1    "
      BITFLD.LONG 0x04 11. "   m5clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 12. "   csysack_cd_m4    , " "0    ,1    "
      BITFLD.LONG 0x04 13. "   csysreq_cd_m4    , " "0    ,1    "
      BITFLD.LONG 0x04 14. "   cactive_cd_m4    , " "0    ,1    "
      BITFLD.LONG 0x04 15. "   m4clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 16. "   csysack_cd_m3    , " "0    ,1    "
      BITFLD.LONG 0x04 17. "   csysreq_cd_m3    , " "0    ,1    "
      BITFLD.LONG 0x04 18. "   cactive_cd_m3    , " "0    ,1    "
      BITFLD.LONG 0x04 19. "   m3clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 20. "   csysack_cd_m2    , " "0    ,1    "
      BITFLD.LONG 0x04 21. "   csysreq_cd_m2    , " "0    ,1    "
      BITFLD.LONG 0x04 22. "   cactive_cd_m2    , " "0    ,1    "
      BITFLD.LONG 0x04 23. "   m2clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 24. "   csysack_cd_m1    , " "0    ,1    "
      BITFLD.LONG 0x04 25. "   csysreq_cd_m1    , " "0    ,1    "
      BITFLD.LONG 0x04 26. "   cactive_cd_m1    , " "0    ,1    "
      BITFLD.LONG 0x04 27. "   m1clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 28. "   csysack_cd_m0    , " "0    ,1    "
      BITFLD.LONG 0x04 29. "   csysreq_cd_m0    , " "0    ,1    "
      BITFLD.LONG 0x04 30. "   cactive_cd_m0    , " "0    ,1    "
      BITFLD.LONG 0x04 31. "   m0clk    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "PUBCP @ chain_lp_dbg_bus1 RO"
;-------------------------------------------------
    VARX 0x08 %l DBUS.read(0x00060200)
    TEXTLINE ""
    LINE.LONG 0x08 "chain_lp_dbg_bus1,chain_lp_dbg_bus1"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x08 0. "   csysack_cd_s6    , " "0    ,1    "
      BITFLD.LONG 0x08 1. "   csysreq_cd_s6    , " "0    ,1    "
      BITFLD.LONG 0x08 2. "   cactive_cd_s6    , " "0    ,1    "
      BITFLD.LONG 0x08 3. "   s6clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 4. "   csysack_cd_s5    , " "0    ,1    "
      BITFLD.LONG 0x08 5. "   csysreq_cd_s5    , " "0    ,1    "
      BITFLD.LONG 0x08 6. "   cactive_cd_s5    , " "0    ,1    "
      BITFLD.LONG 0x08 7. "   s5clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 8. "   csysack_cd_s4    , " "0    ,1    "
      BITFLD.LONG 0x08 9. "   csysreq_cd_s4    , " "0    ,1    "
      BITFLD.LONG 0x08 10. "   cactive_cd_s4    , " "0    ,1    "
      BITFLD.LONG 0x08 11. "   s4clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 12. "   csysack_cd_s3    , " "0    ,1    "
      BITFLD.LONG 0x08 13. "   csysreq_cd_s3    , " "0    ,1    "
      BITFLD.LONG 0x08 14. "   cactive_cd_s3    , " "0    ,1    "
      BITFLD.LONG 0x08 15. "   s3clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 16. "   csysack_cd_s2    , " "0    ,1    "
      BITFLD.LONG 0x08 17. "   csysreq_cd_s2    , " "0    ,1    "
      BITFLD.LONG 0x08 18. "   cactive_cd_s2    , " "0    ,1    "
      BITFLD.LONG 0x08 19. "   s2clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 20. "   csysack_cd_s0    , " "0    ,1    "
      BITFLD.LONG 0x08 21. "   csysreq_cd_s0    , " "0    ,1    "
      BITFLD.LONG 0x08 22. "   cactive_cd_s0    , " "0    ,1    "
      BITFLD.LONG 0x08 23. "   s0clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 24. "   csysack_cd_m9    , " "0    ,1    "
      BITFLD.LONG 0x08 25. "   csysreq_cd_m9    , " "0    ,1    "
      BITFLD.LONG 0x08 26. "   cactive_cd_m9    , " "0    ,1    "
      BITFLD.LONG 0x08 27. "   m9clk    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 28. "   csysack_cd_m8    , " "0    ,1    "
      BITFLD.LONG 0x08 29. "   csysreq_cd_m8    , " "0    ,1    "
      BITFLD.LONG 0x08 30. "   cactive_cd_m8    , " "0    ,1    "
      BITFLD.LONG 0x08 31. "   m8clk    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "PUBCP @ chain_lp_dbg_bus2 RO"
;-------------------------------------------------
    VARX 0x0C %l DBUS.read(0x00060300)
    TEXTLINE ""
    LINE.LONG 0x0C "chain_lp_dbg_bus2,chain_lp_dbg_bus2"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x0C 0. "   lp_stat_main        , " "0    ,1    "
      BITFLD.LONG 0x0C 1. "   lp_stat_abs         , " "0    ,1    "
      BITFLD.LONG 0x0C 2. "   lp_stat_abm         , " "0    ,1    "
      BITFLD.LONG 0x0C 3. "   lp_stat_s6    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 4. "   lp_stat_s5          , " "0    ,1    "
      BITFLD.LONG 0x0C 5. "   lp_stat_s4          , " "0    ,1    "
      BITFLD.LONG 0x0C 6. "   lp_stat_s3          , " "0    ,1    "
      BITFLD.LONG 0x0C 7. "   lp_stat_s2    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 8. "   lp_stat_s0          , " "0    ,1    "
      BITFLD.LONG 0x0C 9. "   lp_stat_m9          , " "0    ,1    "
      BITFLD.LONG 0x0C 10. "   lp_stat_m8          , " "0    ,1    "
      BITFLD.LONG 0x0C 11. "   lp_stat_m7    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 12. "   lp_stat_m6          , " "0    ,1    "
      BITFLD.LONG 0x0C 13. "   lp_stat_m5          , " "0    ,1    "
      BITFLD.LONG 0x0C 14. "   lp_stat_m4          , " "0    ,1    "
      BITFLD.LONG 0x0C 15. "   lp_stat_m3    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 16. "   lp_stat_m2          , " "0    ,1    "
      BITFLD.LONG 0x0C 17. "   lp_stat_m1          , " "0    ,1    "
      BITFLD.LONG 0x0C 18. "   lp_stat_m0          , " "0    ,1    "
      BITFLD.LONG 0x0C 19. "   reserved      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 20. "   csysack_cd_ab_s0    , " "0    ,1    "
      BITFLD.LONG 0x0C 21. "   csysreq_cd_ab_s0    , " "0    ,1    "
      BITFLD.LONG 0x0C 22. "   cactive_cd_ab_s0    , " "0    ,1    "
      BITFLD.LONG 0x0C 23. "   clk_abs       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 24. "   csysack_cd_ab_m0    , " "0    ,1    "
      BITFLD.LONG 0x0C 25. "   csysreq_cd_ab_m0    , " "0    ,1    "
      BITFLD.LONG 0x0C 26. "   cactive_cd_ab_m0    , " "0    ,1    "
      BITFLD.LONG 0x0C 27. "   clk_abm       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 28. "   csysack_cd_main     , " "0    ,1    "
      BITFLD.LONG 0x0C 29. "   csysreq_cd_main     , " "0    ,1    "
      BITFLD.LONG 0x0C 30. "   cactive_cd_main     , " "0    ,1    "
      BITFLD.LONG 0x0C 31. "   mainclk       , " "0    ,1    "
    TEXTLINE ""
    SGROUP "PUBCP @ chain_lp_dbg_bus3 RO"
;-------------------------------------------------
    VARX 0x10 %l DBUS.read(0x00060400)
    TEXTLINE ""
    LINE.LONG 0x10 "chain_lp_dbg_bus3,chain_lp_dbg_bus3"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x10 0. "   rst_axi_tft_n    , " "0    ,1    "
      BITFLD.LONG 0x10 1. "   rst_axi_sec1_n    , " "0    ,1    "
      BITFLD.LONG 0x10 2. "   rst_axi_sec0_n    , " "0    ,1    "
      BITFLD.LONG 0x10 3. "   rst_axi_vic_n      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 4. "   rst_axi_dma_n    , " "0    ,1    "
      BITFLD.LONG 0x10 5. "   rst_cssys_n       , " "0    ,1    "
      BITFLD.LONG 0x10 6. "   rst_cr5_n         , " "0    ,1    "
      BITFLD.LONG 0x10 7. "   rst_axi_wcdma_n    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 8. "   rst_axi_aon_n    , " "0    ,1    "
      BITFLD.LONG 0x10 9. "   rst_apb_n         , " "0    ,1    "
      BITFLD.LONG 0x10 10. "   rst_axi_half_n    , " "0    ,1    "
      BITFLD.LONG 0x10 11. "   rst_axi_n          , " "0    ,1    "
    TEXTLINE ""
    SGROUP "PUBCP @ chain_lp_dbg_bus4 RO"
;-------------------------------------------------
    VARX 0x14 %l DBUS.read(0x00060500)
    TEXTLINE ""
    LINE.LONG 0x14 "chain_lp_dbg_bus4,chain_lp_dbg_bus4"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x14 0. "   cgm_busy_48m     , " "0    ,1    "
      BITFLD.LONG 0x14 1. "   cgm_busy_51_2m     , " "0    ,1    "
      BITFLD.LONG 0x14 2. "   cgm_busy_64m        , " "0    ,1    "
      BITFLD.LONG 0x14 3. "   cgm_busy_96m       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 4. "   cgm_busy_128m    , " "0    ,1    "
      BITFLD.LONG 0x14 5. "   cgm_busy_153_6m    , " "0    ,1    "
      BITFLD.LONG 0x14 6. "   cgm_busy_171_25m    , " "0    ,1    "
      BITFLD.LONG 0x14 7. "   cgm_busy_342_5m    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 8. "   cgm_busy_512m    , " "0    ,1    "
      BITFLD.LONG 0x14 9. "   cgm_busy_685m      , " "0    ,1    "
      BITFLD.LONG 0x14 10. "   cgm_busy_614_4m     , " "0    ,1    "
      BITFLD.LONG 0x14 11. "   cgm_busy_26m       , " "0    ,1    "
    TEXTLINE ""
    SGROUP "PUBCP @ chain_lp_dbg_bus5 RO"
;-------------------------------------------------
    VARX 0x18 %l DBUS.read(0x00060600)
    TEXTLINE ""
    LINE.LONG 0x18 "chain_lp_dbg_bus5,chain_lp_dbg_bus5"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x18 0. "   sdio_eb    , " "0    ,1    "
      BITFLD.LONG 0x18 1. "   aon_access_pubcp    , " "0    ,1    "
      BITFLD.LONG 0x18 2. "   tft_eb      , " "0    ,1    "
      BITFLD.LONG 0x18 3. "   sec1_eb          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 4. "   sec0_eb    , " "0    ,1    "
      BITFLD.LONG 0x18 5. "   dma_eb              , " "0    ,1    "
      BITFLD.LONG 0x18 6. "   dma_busy    , " "0    ,1    "
      BITFLD.LONG 0x18 7. "   dma_link_busy    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 8. "   iis0_eb    , " "0    ,1    "
      BITFLD.LONG 0x18 9. "   uart0_eb            , " "0    ,1    "
    SGROUP "PUBCP @ chain_lp_dbg_bus6 RO"
;-------------------------------------------------
    VARX 0x1C %l DBUS.read(0x00060700)
    TEXTLINE ""
    LINE.LONG 0x1C "chain_lp_dbg_bus6,chain_lp_dbg_bus6"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x1C 0. "   cr5_standbywfi_n       , " "0    ,1    "
      BITFLD.LONG 0x1C 1. "   mcu_core_sleep          , " "0    ,1    "
      BITFLD.LONG 0x1C 2. "   pubcp_sys_cr5_stop      , " "0    ,1    "
      BITFLD.LONG 0x1C 3. "   mcu_peri_stop          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 4. "   pubcp_sys_deep_stop    , " "0    ,1    "
      BITFLD.LONG 0x1C 5. "   pubcp_sys_light_stop    , " "0    ,1    "
      BITFLD.LONG 0x1C 6. "   cgm_apb_en              , " "0    ,1    "
      BITFLD.LONG 0x1C 7. "   cgm_cr5_AXI_div2_en    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 8. "   cgm_cr5_axi_en         , " "0    ,1    "
      BITFLD.LONG 0x1C 9. "   cgm_cr5_core_en         , " "0    ,1    "
      BITFLD.LONG 0x1C 10. "   apb_trans_blk_bypass    , " "0    ,1    "
TREE.END
;###################Tree###################
TREE "MDAR"
    SGROUP "MDAR @ chain_rfti_dbg_bus RO"
;-------------------------------------------------
    VARX 0x04 %l DBUS.read(0x00070000)
    TEXTLINE ""
    LINE.LONG 0x04 "chain_rfti_dbg_bus,chain_rfti_dbg_bus"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x04 0. "   rfti_sys_dbg_bus[0]     , " "0    ,1    "
      BITFLD.LONG 0x04 1. "   rfti_sys_dbg_bus[1]     , " "0    ,1    "
      BITFLD.LONG 0x04 2. "   rfti_sys_dbg_bus[2]     , " "0    ,1    "
      BITFLD.LONG 0x04 3. "   rfti_sys_dbg_bus[3]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 4. "   rfti_sys_dbg_bus[4]     , " "0    ,1    "
      BITFLD.LONG 0x04 5. "   rfti_sys_dbg_bus[5]     , " "0    ,1    "
      BITFLD.LONG 0x04 6. "   rfti_sys_dbg_bus[6]     , " "0    ,1    "
      BITFLD.LONG 0x04 7. "   rfti_sys_dbg_bus[7]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 8. "   rfti_sys_dbg_bus[8]     , " "0    ,1    "
      BITFLD.LONG 0x04 9. "   rfti_sys_dbg_bus[9]     , " "0    ,1    "
      BITFLD.LONG 0x04 10. "   rfti_sys_dbg_bus[10]    , " "0    ,1    "
      BITFLD.LONG 0x04 11. "   rfti_sys_dbg_bus[11]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 12. "   rfti_sys_dbg_bus[12]    , " "0    ,1    "
      BITFLD.LONG 0x04 13. "   rfti_sys_dbg_bus[13]    , " "0    ,1    "
      BITFLD.LONG 0x04 14. "   rfti_sys_dbg_bus[14]    , " "0    ,1    "
      BITFLD.LONG 0x04 15. "   rfti_sys_dbg_bus[15]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 16. "   rfti_sys_dbg_bus[16]    , " "0    ,1    "
      BITFLD.LONG 0x04 17. "   rfti_sys_dbg_bus[17]    , " "0    ,1    "
      BITFLD.LONG 0x04 18. "   rfti_sys_dbg_bus[18]    , " "0    ,1    "
      BITFLD.LONG 0x04 19. "   rfti_sys_dbg_bus[19]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 20. "   rfti_sys_dbg_bus[20]    , " "0    ,1    "
      BITFLD.LONG 0x04 21. "   rfti_sys_dbg_bus[21]    , " "0    ,1    "
      BITFLD.LONG 0x04 22. "   rfti_sys_dbg_bus[22]    , " "0    ,1    "
      BITFLD.LONG 0x04 23. "   rfti_sys_dbg_bus[23]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 24. "   rfti_sys_dbg_bus[24]    , " "0    ,1    "
      BITFLD.LONG 0x04 25. "   rfti_sys_dbg_bus[25]    , " "0    ,1    "
      BITFLD.LONG 0x04 26. "   rfti_sys_dbg_bus[26]    , " "0    ,1    "
      BITFLD.LONG 0x04 27. "   rfti_sys_dbg_bus[27]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 28. "   rfti_sys_dbg_bus[28]    , " "0    ,1    "
      BITFLD.LONG 0x04 29. "   rfti_sys_dbg_bus[29]    , " "0    ,1    "
      BITFLD.LONG 0x04 30. "   rfti_sys_dbg_bus[30]    , " "0    ,1    "
      BITFLD.LONG 0x04 31. "   rfti_sys_dbg_bus[31]    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "MDAR @ chain_lvds_dbg_bus RO"
;-------------------------------------------------
    VARX 0x08 %l DBUS.read(0x00070100)
    TEXTLINE ""
    LINE.LONG 0x08 "chain_lvds_dbg_bus,chain_lvds_dbg_bus"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x08 0. "   M_LVDSRF_LVPLL_PD    , " "0    ,1    "
      BITFLD.LONG 0x08 1. "   M_LVDSRF_LPLL_RST    , " "0    ,1    "
      BITFLD.LONG 0x08 2. "   M_LVDSRF_LVPLL_LOCKDONE    , " "0    ,1    "
      BITFLD.LONG 0x08 3. "   1'b0                 , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 4. "   M_LVDSRF_RXPD0       , " "0    ,1    "
      BITFLD.LONG 0x08 5. "   M_LVDSRF_DES_RST0    , " "0    ,1    "
      BITFLD.LONG 0x08 6. "   M_LVDSRF_RXPD1             , " "0    ,1    "
      BITFLD.LONG 0x08 7. "   M_LVDSRF_DES_RST1    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 8. "   M_LVDSRF_RXPD2       , " "0    ,1    "
      BITFLD.LONG 0x08 9. "   M_LVDSRF_DES_RST2    , " "0    ,1    "
      BITFLD.LONG 0x08 10. "   M_LVDSRF_RXPD3             , " "0    ,1    "
      BITFLD.LONG 0x08 11. "   M_LVDSRF_DES_RST3    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 12. "   M_LVDSRF_TXPD0       , " "0    ,1    "
      BITFLD.LONG 0x08 13. "   M_LVDSRF_SER_RST0    , " "0    ,1    "
      BITFLD.LONG 0x08 14. "   M_LVDSRF_TXPD1             , " "0    ,1    "
      BITFLD.LONG 0x08 15. "   M_LVDSRF_SER_RST1    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 16. "   RPLL_PD              , " "0    ,1    "
      BITFLD.LONG 0x08 17. "   RPLL_RST             , " "0    ,1    "
      BITFLD.LONG 0x08 18. "   RPLL_LOCK_DONE             , " "0    ,1    "
TREE.END
;###################Tree###################
TREE "MM"
    SGROUP "MM @ chain_mm_eb RO"
;-------------------------------------------------
    VARX 0x04 %l DBUS.read(0x00080100)
    TEXTLINE ""
    LINE.LONG 0x04 "chain_mm_eb,chain_mm_eb"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x04 0. "   mm_eb             , " "0    ,1    "
      BITFLD.LONG 0x04 1. "   cphy_cfg_ckg_en    , " "0    ,1    "
      BITFLD.LONG 0x04 2. "   jpg_eb               , " "0    ,1    "
      BITFLD.LONG 0x04 3. "   isp_eb            , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 4. "   vsp_eb            , " "0    ,1    "
      BITFLD.LONG 0x04 5. "   dcam_eb            , " "0    ,1    "
      BITFLD.LONG 0x04 6. "   sensor0_ckg_en       , " "0    ,1    "
      BITFLD.LONG 0x04 7. "   cpp_eb            , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 8. "   sensor1_ckg_en    , " "0    ,1    "
      BITFLD.LONG 0x04 9. "   csi_eb             , " "0    ,1    "
      BITFLD.LONG 0x04 10. "   csi_s_eb             , " "0    ,1    "
      BITFLD.LONG 0x04 11. "   isp_axi_ckg_en    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 12. "   ckg_eb            , " "0    ,1    "
      BITFLD.LONG 0x04 13. "   mipi_csi_ckg_en    , " "0    ,1    "
      BITFLD.LONG 0x04 14. "   mipi_csi_s_ckg_en    , " "0    ,1    "
      BITFLD.LONG 0x04 15. "   cbm_eb            , " "0    ,1    "
    TEXTLINE ""
    SGROUP "MM @ chain_mm_clk RO"
;-------------------------------------------------
    VARX 0x08 %l DBUS.read(0x00080200)
    TEXTLINE ""
    LINE.LONG 0x08 "chain_mm_clk,chain_mm_clk"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x08 0. "   pclk_sec_128m_scan     , " "0    ,1    "
      BITFLD.LONG 0x08 1. "   djtag_tckn_scan        , " "0    ,1    "
      BITFLD.LONG 0x08 2. "   djtag_tck_scan      , " "0    ,1    "
      BITFLD.LONG 0x08 3. "   clk_axi_mm_vsp_emc_scan    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 4. "   clk_axi_mm_emc_scan    , " "0    ,1    "
      BITFLD.LONG 0x08 5. "   clk_axi_ap_mm_scan     , " "0    ,1    "
      BITFLD.LONG 0x08 6. "   HCLK_sys            , " "0    ,1    "
      BITFLD.LONG 0x08 7. "   1'b0                       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 8. "   clk_mipi_csi_s         , " "0    ,1    "
      BITFLD.LONG 0x08 9. "   clk_mipi_csi           , " "0    ,1    "
      BITFLD.LONG 0x08 10. "   clk_cpp             , " "0    ,1    "
      BITFLD.LONG 0x08 11. "   clk_jpg                    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 12. "   clk_isp                , " "0    ,1    "
      BITFLD.LONG 0x08 13. "   clk_vsp                , " "0    ,1    "
      BITFLD.LONG 0x08 14. "   clk_dcam            , " "0    ,1    "
      BITFLD.LONG 0x08 15. "   clk_cpp_pre_fdiv           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 16. "   clk_jpg_pre_fdiv       , " "0    ,1    "
      BITFLD.LONG 0x08 17. "   clk_isp_pre_fdiv       , " "0    ,1    "
      BITFLD.LONG 0x08 18. "   clk_vsp_pre_fdiv    , " "0    ,1    "
      BITFLD.LONG 0x08 19. "   clk_dcam_pre_fdiv          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 20. "   clk_sensor1_iso_in_    , " "0    ,1    "
      BITFLD.LONG 0x08 21. "   clk_sensor0_iso_in_    , " "0    ,1    "
    SGROUP "MM @ chain_mm_cgm RO"
;-------------------------------------------------
    VARX 0x0C %l DBUS.read(0x00080300)
    TEXTLINE ""
    LINE.LONG 0x0C "chain_mm_cgm,chain_mm_cgm"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x0C 0. "   cgm_busy_24m_iso_in_     , " "0    ,1    "
      BITFLD.LONG 0x0C 1. "   cgm_busy_48m_iso_in_       , " "0    ,1    "
      BITFLD.LONG 0x0C 2. "   cgm_busy_64m_iso_in_       , " "0    ,1    "
      BITFLD.LONG 0x0C 3. "   cgm_busy_76_8m_iso_in_    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 4. "   cgm_busy_96m_iso_in_     , " "0    ,1    "
      BITFLD.LONG 0x0C 5. "   cgm_busy_128m_iso_in_      , " "0    ,1    "
      BITFLD.LONG 0x0C 6. "   cgm_busy_153_6m_iso_in_    , " "0    ,1    "
      BITFLD.LONG 0x0C 7. "   cgm_busy_192m_iso_in_     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 8. "   cgm_busy_256m_iso_in_    , " "0    ,1    "
      BITFLD.LONG 0x0C 9. "   cgm_busy_307_2m_iso_in_    , " "0    ,1    "
      BITFLD.LONG 0x0C 10. "   cgm_busy_468m_iso_in_      , " "0    ,1    "
      BITFLD.LONG 0x0C 11. "   cgm_busy_512m_iso_in_     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 12. "   cgm_busy_384m_iso_in_    , " "0    ,1    "
      BITFLD.LONG 0x0C 13. "   cgm_busy_26m_iso_in_       , " "0    ,1    "
    SGROUP "MM @ chain_mm_djtag RO"
;-------------------------------------------------
    VARX 0x10 %l DBUS.read(0x00080400)
    TEXTLINE ""
    LINE.LONG 0x10 "chain_mm_djtag,chain_mm_djtag"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x10 0. "   pclk_sec_128m     , " "0    ,1    "
      BITFLD.LONG 0x10 1. "   djtag_tckn       , " "0    ,1    "
      BITFLD.LONG 0x10 2. "   djtag_tck                  , " "0    ,1    "
      BITFLD.LONG 0x10 3. "   clk_axi_mm_vsp_emc       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 4. "   clk_axi_mm_emc    , " "0    ,1    "
      BITFLD.LONG 0x10 5. "   clk_axi_ap_mm    , " "0    ,1    "
      BITFLD.LONG 0x10 6. "   mipi_csi2_rxbyteclkhs_s    , " "0    ,1    "
      BITFLD.LONG 0x10 7. "   mipi_csi2_rxbyteclkhs    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "MM @ chain_mm_dcam RO"
;-------------------------------------------------
    VARX 0x14 %l DBUS.read(0x00080500)
    TEXTLINE ""
    LINE.LONG 0x14 "chain_mm_dcam,chain_mm_dcam"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x14 0.--3. "   dcam_idi_dvalid[3:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x14 4.--7. "   dcam_idi_hvalid[3:0]         , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x14 8.--11. "   dcam_idi_vvalid[3:0]             , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x14 12.--13. "   dcam_idi_bytes_en[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    TEXTLINE ""
      BITFLD.LONG 0x14 14. "   dcam_idi_data_en        , " "0    ,1    "
      BITFLD.LONG 0x14 15.--20. "   dcam_idi_data_type[5:0]      , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
      BITFLD.LONG 0x14 21.--22. "   dcam_idi_virtual_channel[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x14 23. "   dcam_idi_head_en          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 24. "   dcam_irq                , " "0    ,1    "
      BITFLD.LONG 0x14 25. "   isp_fifo_full                , " "0    ,1    "
      BITFLD.LONG 0x14 26. "   isp_out_sof                      , " "0    ,1    "
      BITFLD.LONG 0x14 27. "   isp_out_eof               , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 28. "   dcam_wr_en              , " "0    ,1    "
      BITFLD.LONG 0x14 29.--31. "   idi_sw_current_state[2:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    SGROUP "MM @ chain_mm_idi RO"
;-------------------------------------------------
    VARX 0x18 %l DBUS.read(0x00080600)
    TEXTLINE ""
    LINE.LONG 0x18 "chain_mm_idi,chain_mm_idi"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x18 0.--3. "   idi_vvalid[3:0]      , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x18 4.--5. "   idi_virtual_channel[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x18 6.--9. "   idi_hvalid[3:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x18 10. "   idi_header_en        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 11.--14. "   idi_dvalid[3:0]      , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x18 15. "   idi_data_type[0]            , " "0    ,1    "
      BITFLD.LONG 0x18 16. "   idi_data_en        , " "0    ,1    "
      BITFLD.LONG 0x18 17.--18. "   idi_bytes_en[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    TEXTLINE ""
      BITFLD.LONG 0x18 19.--25. "   idi_csi_data[6:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
      BITFLD.LONG 0x18 26.--31. "   idi_csi_data[20:15]         , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
    SGROUP "MM @ chain_mm_idi1 RO"
;-------------------------------------------------
    VARX 0x1C %l DBUS.read(0x00080700)
    TEXTLINE ""
    LINE.LONG 0x1C "chain_mm_idi1,chain_mm_idi1"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x1C 0.--3. "   idi_vvalid_s[3:0]      , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x1C 4.--5. "   idi_virtual_channel_s[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x1C 6.--9. "   idi_hvalid_s[3:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x1C 10. "   idi_header_en_s        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 11.--14. "   idi_dvalid_s[3:0]      , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
      BITFLD.LONG 0x1C 15. "   idi_data_type_s[0]            , " "0    ,1    "
      BITFLD.LONG 0x1C 16. "   idi_data_en_s        , " "0    ,1    "
      BITFLD.LONG 0x1C 17.--18. "   idi_bytes_en_s[1:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,%x..."
    TEXTLINE ""
      BITFLD.LONG 0x1C 19.--25. "   idi_csi_data_S[6:0]    , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
      BITFLD.LONG 0x1C 26.--31. "   idi_csi_data_s[20:15]         , " "0x0  ,0x1  ,0x2  ,0x3  ,0x4  ,0x5  ,0x6  ,0x7  ,%x..."
    SGROUP "MM @ chain_mm_busmon RO"
;-------------------------------------------------
    VARX 0x20 %l DBUS.read(0x00080800)
    TEXTLINE ""
    LINE.LONG 0x20 "chain_mm_busmon,chain_mm_busmon"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x20 0. "   cactive_cd_main        , " "0    ,1    "
      BITFLD.LONG 0x20 1. "   csysack_cd_main        , " "0    ,1    "
      BITFLD.LONG 0x20 2. "   cactive_cd_s0          , " "0    ,1    "
      BITFLD.LONG 0x20 3. "   csysack_cd_s0         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 4. "   cactive_cd_m1          , " "0    ,1    "
      BITFLD.LONG 0x20 5. "   csysack_cd_m1          , " "0    ,1    "
      BITFLD.LONG 0x20 6. "   cactive_cd_m0          , " "0    ,1    "
      BITFLD.LONG 0x20 7. "   csysack_cd_m0         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 8. "   cactive_cd_main_vsp    , " "0    ,1    "
      BITFLD.LONG 0x20 9. "   csysack_cd_main_vsp    , " "0    ,1    "
      BITFLD.LONG 0x20 10. "   cactive_cd_s0_vsp      , " "0    ,1    "
      BITFLD.LONG 0x20 11. "   csysack_cd_s0_vsp     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 12. "   cactive_cd_m2_vsp      , " "0    ,1    "
      BITFLD.LONG 0x20 13. "   csysack_cd_m2_vsp      , " "0    ,1    "
      BITFLD.LONG 0x20 14. "   cactive_cd_m1_vsp      , " "0    ,1    "
      BITFLD.LONG 0x20 15. "   csysack_cd_m1_vsp     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 16. "   cactive_cd_m0_vsp      , " "0    ,1    "
      BITFLD.LONG 0x20 17. "   csysack_cd_m0_vsp      , " "0    ,1    "
      BITFLD.LONG 0x20 18. "   cpp_arm_int            , " "0    ,1    "
      BITFLD.LONG 0x20 19. "   jpg_irq               , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 20. "   isp_irq_ch1            , " "0    ,1    "
      BITFLD.LONG 0x20 21. "   isp_irq_ch0            , " "0    ,1    "
      BITFLD.LONG 0x20 22. "   cbm_irq                , " "0    ,1    "
      BITFLD.LONG 0x20 23. "   dcam_irq              , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 24. "   vsp_irq                , " "0    ,1    "
      BITFLD.LONG 0x20 25. "   int_req_busmon_cpp     , " "0    ,1    "
      BITFLD.LONG 0x20 26. "   int_req_busmon_dcam    , " "0    ,1    "
      BITFLD.LONG 0x20 27. "   int_req_busmon_vsp    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 28. "   int_req_busmon_jpg     , " "0    ,1    "
      BITFLD.LONG 0x20 29. "   int_req_busmon_isp     , " "0    ,1    "
TREE.END
;###################Tree###################
TREE "AON"
    SGROUP "AON @ chain_aon_dfs RO"
;-------------------------------------------------
    VARX 0x04 %l DBUS.read(0x00090200)
    TEXTLINE ""
    LINE.LONG 0x04 "chain_aon_dfs,chain_aon_dfs"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x04 0. "   dfs_fc_req                     , dfs hand shake signal" "0    ,1    "
      BITFLD.LONG 0x04 1. "   dfs_fc_req_o            , dfs hand shake signal" "0    ,1    "
      BITFLD.LONG 0x04 2. "   dfs_fc_ack           , dfs hand shake signal" "0    ,1    "
      BITFLD.LONG 0x04 3. "   dfs_fc_ack_i      , dfs hand shake signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 4. "   pub_dfs_sw_ack                 , dfs hand shake signal" "0    ,1    "
      BITFLD.LONG 0x04 5. "   pub_dfs_sw_req          , dfs hand shake signal" "0    ,1    "
      BITFLD.LONG 0x04 6. "   dfs_ack              , dfs hand shake signal" "0    ,1    "
      BITFLD.LONG 0x04 7. "   dfs_req           , dfs hand shake signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 8. "   pub_dfs_sw_despll_auto_mode    , dfs control signal" "0    ,1    "
      BITFLD.LONG 0x04 9. "   pub_dfs_sw_despll_en    , dfs control signal" "0    ,1    "
      BITFLD.LONG 0x04 10. "   pub_dfs_sw_ebable    , dfs control signal" "0    ,1    "
      BITFLD.LONG 0x04 11. "   emc_ckg_sel[0]    , ddr clock control signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 12. "   emc_ckg_sel[1]                 , ddr clock control signal" "0    ,1    "
      BITFLD.LONG 0x04 13. "   emc_ckg_sel[2]          , ddr clock control signal" "0    ,1    "
      BITFLD.LONG 0x04 14. "   emc_ckg_sel[3]       , ddr clock control signal" "0    ,1    "
      BITFLD.LONG 0x04 15. "   emc_ckg_sel[4]    , ddr clock control signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 16. "   dfs_fc_sel[0]                  , ddr clock control signal" "0    ,1    "
      BITFLD.LONG 0x04 17. "   dfs_fc_sel[1]           , ddr clock control signal" "0    ,1    "
      BITFLD.LONG 0x04 18. "   despll_rst           , despll control signal" "0    ,1    "
      BITFLD.LONG 0x04 19. "   despll_pd         , despll control signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 20. "   DESPLL_LOCK_DONE               , despll control signal" "0    ,1    "
      BITFLD.LONG 0x04 21. "   despll_ctrl_sel         , despll control signal" "0    ,1    "
    SGROUP "AON @ chain_aon_pend RO"
;-------------------------------------------------
    VARX 0x08 %l DBUS.read(0x00090300)
    TEXTLINE ""
    LINE.LONG 0x08 "chain_aon_pend,chain_aon_pend"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x08 8. "   aw_hdshk_pend    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x08 9. "   w_hdshk_pend    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x08 10. "   b_hdsjk_pend    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x08 11. "   ar_hdshk_pend    , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 12. "   r_hdshk_pend     , cpu2gpu axi monitor signal" "0    ,1    "
    SGROUP "AON @ chain_aon_rchn RO"
;-------------------------------------------------
    VARX 0x0C %l DBUS.read(0x00090400)
    TEXTLINE ""
    LINE.LONG 0x0C "chain_aon_rchn,chain_aon_rchn"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x0C 0. "   rchn_id_rec_u0[0]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 1. "   rchn_id_rec_u0[1]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 2. "   rchn_id_rec_u0[2]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 3. "   rchn_id_rec_u0[3]    , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 4. "   rchn_id_rec_u0[4]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 5. "   rchn_id_rec_u0[5]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 6. "   rchn_id_rec_u0[6]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 7. "   rchn_id_rec_u0[7]    , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 8. "   rchn_id_rec_u0[8]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 9. "   rchn_pend_u0         , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 10. "   rchn_id_rec_u1[0]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 11. "   rchn_id_rec_u1[1]    , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 12. "   rchn_id_rec_u1[2]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 13. "   rchn_id_rec_u1[3]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 14. "   rchn_id_rec_u1[4]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 15. "   rchn_id_rec_u1[5]    , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 16. "   rchn_id_rec_u1[6]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 17. "   rchn_id_rec_u1[7]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 18. "   rchn_id_rec_u1[8]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 19. "   rchn_pend_u1         , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 20. "   rchn_id_rec_u2[0]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 21. "   rchn_id_rec_u2[1]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 22. "   rchn_id_rec_u2[2]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 23. "   rchn_id_rec_u2[3]    , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 24. "   rchn_id_rec_u2[4]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 25. "   rchn_id_rec_u2[5]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 26. "   rchn_id_rec_u2[6]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 27. "   rchn_id_rec_u2[7]    , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 28. "   rchn_id_rec_u2[8]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 29. "   rchn_pend_u2         , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 30. "   rchn_id_rec_u3[0]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x0C 31. "   rchn_id_rec_u3[1]    , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_wchn RO"
;-------------------------------------------------
    VARX 0x10 %l DBUS.read(0x00090500)
    TEXTLINE ""
    LINE.LONG 0x10 "chain_aon_wchn,chain_aon_wchn"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x10 0. "   wchn_id_rec_u0[0]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 1. "   wchn_id_rec_u0[1]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 2. "   wchn_id_rec_u0[2]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 3. "   wchn_id_rec_u0[3]    , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 4. "   wchn_id_rec_u0[4]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 5. "   wchn_id_rec_u0[5]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 6. "   wchn_id_rec_u0[6]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 7. "   wchn_id_rec_u0[7]    , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 8. "   wchn_id_rec_u0[8]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 9. "   wchn_pend_u0         , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 10. "   wchn_id_rec_u1[0]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 11. "   wchn_id_rec_u1[1]    , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 12. "   wchn_id_rec_u1[2]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 13. "   wchn_id_rec_u1[3]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 14. "   wchn_id_rec_u1[4]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 15. "   wchn_id_rec_u1[5]    , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 16. "   wchn_id_rec_u1[6]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 17. "   wchn_id_rec_u1[7]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 18. "   wchn_id_rec_u1[8]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 19. "   wchn_pend_u1         , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 20. "   wchn_id_rec_u2[0]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 21. "   wchn_id_rec_u2[1]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 22. "   wchn_id_rec_u2[2]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 23. "   wchn_id_rec_u2[3]    , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 24. "   wchn_id_rec_u2[4]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 25. "   wchn_id_rec_u2[5]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 26. "   wchn_id_rec_u2[6]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 27. "   wchn_id_rec_u2[7]    , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 28. "   wchn_id_rec_u2[8]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 29. "   wchn_pend_u2         , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 30. "   wchn_id_rec_u3[0]    , cpu2gpu axi monitor signal" "0    ,1    "
      BITFLD.LONG 0x10 31. "   wchn_id_rec_u3[1]    , cpu2gpu axi monitor signal" "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_volt RO"
;-------------------------------------------------
    VARX 0x14 %l DBUS.read(0x00090700)
    TEXTLINE ""
    LINE.LONG 0x14 "chain_aon_volt,chain_aon_volt"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x14 0. "   current_state[0]     , scc top" "0    ,1    "
      BITFLD.LONG 0x14 1. "   current_state[1]      , scc top" "0    ,1    "
      BITFLD.LONG 0x14 2. "   current_state[2]     , scc top" "0    ,1    "
      BITFLD.LONG 0x14 3. "   current_state[3]    , scc top" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 4. "   current_state[4]     , scc top" "0    ,1    "
      BITFLD.LONG 0x14 5. "   int_req_scc           , scc top" "0    ,1    "
      BITFLD.LONG 0x14 6. "   pulse_cnt_lt_zero    , scc top" "0    ,1    "
      BITFLD.LONG 0x14 7. "   more_to_scan        , scc top" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 8. "   rosc_rpt_read_flg    , scc top" "0    ,1    "
      BITFLD.LONG 0x14 9. "   scc_rosc_rpt_valid    , scc top" "0    ,1    "
      BITFLD.LONG 0x14 10. "   volt_obs_val[0]      , scc top" "0    ,1    "
      BITFLD.LONG 0x14 11. "   volt_obs_val[1]     , scc top" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 12. "   volt_obs_val[2]      , scc top" "0    ,1    "
      BITFLD.LONG 0x14 13. "   volt_obs_val[3]       , scc top" "0    ,1    "
      BITFLD.LONG 0x14 14. "   volt_obs_val[4]      , scc top" "0    ,1    "
      BITFLD.LONG 0x14 15. "   volt_obs_val[5]     , scc top" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 16. "   volt_obs_val[6]      , scc top" "0    ,1    "
      BITFLD.LONG 0x14 17. "   volt_obs_val[7]       , scc top" "0    ,1    "
      BITFLD.LONG 0x14 18. "   volt_obs_ack         , scc top" "0    ,1    "
      BITFLD.LONG 0x14 19. "   volt_obs_req        , scc top" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 20. "   volt_tune_val[0]     , scc top" "0    ,1    "
      BITFLD.LONG 0x14 21. "   volt_tune_val[1]      , scc top" "0    ,1    "
      BITFLD.LONG 0x14 22. "   volt_tune_val[2]     , scc top" "0    ,1    "
      BITFLD.LONG 0x14 23. "   volt_tune_val[3]    , scc top" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 24. "   volt_tune_val[4]     , scc top" "0    ,1    "
      BITFLD.LONG 0x14 25. "   volt_tune_val[5]      , scc top" "0    ,1    "
      BITFLD.LONG 0x14 26. "   volt_tune_val[6]     , scc top" "0    ,1    "
      BITFLD.LONG 0x14 27. "   volt_tune_val[7]    , scc top" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x14 28. "   volt_tune_ack        , scc top" "0    ,1    "
      BITFLD.LONG 0x14 29. "   volt_tune_req         , scc top" "0    ,1    "
      BITFLD.LONG 0x14 30. "   volt0_select         , scc top" "0    ,1    "
      BITFLD.LONG 0x14 31. "   volt1_select        , scc top" "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_slice RO"
;-------------------------------------------------
    VARX 0x18 %l DBUS.read(0x00090800)
    TEXTLINE ""
    LINE.LONG 0x18 "chain_aon_slice,chain_aon_slice"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x18 0. "   u_reg_slice_axi_mm_vsp_emc_0_lpc_lp_stat         , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 1. "   u_reg_slice_axi_mm_emc_0_lpc_lp_stat               , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 2. "   u_reg_slice_axi_gpu_emc_0_lpc_lp_stat         , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 3. "   u_reg_slice_axi_cp1ca5_emc_0_lpc_lp_stat    , axi slice lpc state" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 4. "   u_reg_slice_axi_pubcp_wtlcp_dsp_0_lpc_lp_stat    , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 5. "   u_reg_slice_axi_pubcp_wtlcp_wcdma_0_lpc_lp_stat    , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 6. "   u_reg_slice_axi_gpu_ca53_cci_0_lpc_lp_stat    , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 7. "   u_reg_slice_axi_ca53_emc_0_lpc_lp_stat      , axi slice lpc state" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 8. "   u_reg_slice_axi_mm_vsp_emc_0_lpc_csysreq         , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 9. "   u_reg_slice_axi_mm_emc_0_lpc_csysreq               , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 10. "   u_reg_slice_axi_gpu_emc_0_lpc_csysreq         , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 11. "   u_reg_slice_axi_cp1ca5_emc_0_lpc_csysreq    , axi slice lpc state" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 12. "   u_reg_slice_axi_pubcp_wtlcp_dsp_0_lpc_csysreq    , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 13. "   u_reg_slice_axi_pubcp_wtlcp_wcdma_0_lpc_csysreq    , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 14. "   u_reg_slice_axi_gpu_ca53_cci_0_lpc_csysreq    , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 15. "   u_reg_slice_axi_ca53_emc_0_lpc_csysreq      , axi slice lpc state" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 16. "   u_reg_slice_axi_mm_vsp_emc_0_lpc_csysack         , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 17. "   u_reg_slice_axi_mm_emc_0_lpc_csysack               , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 18. "   u_reg_slice_axi_gpu_emc_0_lpc_csysack         , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 19. "   u_reg_slice_axi_cp1ca5_emc_0_lpc_csysack    , axi slice lpc state" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 20. "   u_reg_slice_axi_pubcp_wtlcp_dsp_0_lpc_csysack    , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 21. "   u_reg_slice_axi_pubcp_wtlcp_wcdma_0_lpc_csysack    , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 22. "   u_reg_slice_axi_gpu_ca53_cci_0_lpc_csysack    , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 23. "   u_reg_slice_axi_ca53_emc_0_lpc_csysack      , axi slice lpc state" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 24. "   u_reg_slice_axi_mm_vsp_emc_0_cactive             , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 25. "   u_reg_slice_axi_mm_emc_0_cactive                   , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 26. "   u_reg_slice_axi_gpu_emc_0_cactive             , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 27. "   u_reg_slice_axi_cp1ca5_emc_0_cactive        , axi slice lpc state" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x18 28. "   u_reg_slice_axi_pubcp_wtlcp_dsp_0_cactive        , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 29. "   u_reg_slice_axi_pubcp_wtlcp_wcdma_0_cactive        , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 30. "   u_reg_slice_axi_gpu_ca53_cci_0_cactive        , axi slice lpc state" "0    ,1    "
      BITFLD.LONG 0x18 31. "   u_reg_slice_axi_ca53_emc_0_cactive          , axi slice lpc state" "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_cactive RO"
;-------------------------------------------------
    VARX 0x1C %l DBUS.read(0x00090900)
    TEXTLINE ""
    LINE.LONG 0x1C "chain_aon_cactive,chain_aon_cactive"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x1C 0. "   cactive_cd_s10    , aon bus matrix state" "0    ,1    "
      BITFLD.LONG 0x1C 1. "   cactive_cd_s9    , aon bus matrix state" "0    ,1    "
      BITFLD.LONG 0x1C 2. "   cactive_cd_s8    , aon bus matrix state" "0    ,1    "
      BITFLD.LONG 0x1C 3. "   cactive_cd_s7      , aon bus matrix state" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 4. "   cactive_cd_emc    , aon bus matrix state" "0    ,1    "
      BITFLD.LONG 0x1C 5. "   cactive_cd_s5    , aon bus matrix state" "0    ,1    "
      BITFLD.LONG 0x1C 6. "   cactive_cd_s4    , aon bus matrix state" "0    ,1    "
      BITFLD.LONG 0x1C 7. "   cactive_cd_s2      , aon bus matrix state" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 8. "   cactive_cd_s1     , aon bus matrix state" "0    ,1    "
      BITFLD.LONG 0x1C 9. "   cactive_cd_s0    , aon bus matrix state" "0    ,1    "
      BITFLD.LONG 0x1C 10. "   cactive_funcdma  , aon bus matrix state" "0    ,1    "
      BITFLD.LONG 0x1C 11. "   cactive_arm7       , aon bus matrix state" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x1C 12. "   cactive_dma       , aon bus matrix state" "0    ,1    "
      BITFLD.LONG 0x1C 13. "   cactive_pubcp    , aon bus matrix state" "0    ,1    "
      BITFLD.LONG 0x1C 14. "   cactive_wtlcp    , aon bus matrix state" "0    ,1    "
      BITFLD.LONG 0x1C 15. "   cactive_ap         , aon bus matrix state" "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_sleep RO"
;-------------------------------------------------
    VARX 0x20 %l DBUS.read(0x00090101)
    TEXTLINE ""
    LINE.LONG 0x20 "chain_aon_sleep,chain_aon_sleep"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x20 0. "   all_sys_pwr_pd          , " "0    ,1    "
      BITFLD.LONG 0x20 1. "   pubcp_light_sleep              , light sleep signal" "0    ,1    "
      BITFLD.LONG 0x20 2. "   wtlcp_light_sleep            , light sleep signal" "0    ,1    "
      BITFLD.LONG 0x20 3. "   arm7_light_sleep        , light sleep signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 4. "   aon_dma_light_sleep     , light sleep signal" "0    ,1    "
      BITFLD.LONG 0x20 5. "   all_light_sleep                , " "0    ,1    "
      BITFLD.LONG 0x20 6. "   eic_light_sleep_sel          , " "0    ,1    "
      BITFLD.LONG 0x20 7. "   ap_deep_sleep           , deep sleep signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 8. "   pubcp_deep_sleep        , deep sleep signal" "0    ,1    "
      BITFLD.LONG 0x20 9. "   wtlcp_deep_sleep               , deep sleep signal" "0    ,1    "
      BITFLD.LONG 0x20 10. "   ap_pub_deep_sleep            , deep sleep signal" "0    ,1    "
      BITFLD.LONG 0x20 11. "   pubcp_pub_deep_sleep    , deep sleep signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 12. "   wtlcp_pub_deep_sleep    , deep sleep signal" "0    ,1    "
      BITFLD.LONG 0x20 13. "   all_pwr_pd                     , all subsys deep sleep" "0    ,1    "
      BITFLD.LONG 0x20 14. "   all_arm7_pwr_pd              , all subsys deep sleep + arm7 sleep" "0    ,1    "
      BITFLD.LONG 0x20 15. "   eic_deep_sleep_sel      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 16. "   ap_pwr_pd               , deep sleep signal through slp_state" "0    ,1    "
      BITFLD.LONG 0x20 17. "   wtlcp_pwr_pd                   , deep sleep signal through slp_state" "0    ,1    "
      BITFLD.LONG 0x20 18. "   pubcp_pwr_pd                 , deep sleep signal through slp_state" "0    ,1    "
      BITFLD.LONG 0x20 19. "   pub_deep_sleep          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 20. "   arm7_pwr_pd             , arm7 sleep signal through slp_state" "0    ,1    "
      BITFLD.LONG 0x20 21. "   pd_pub_sys_auto_shutdown_en    , apb reg" "0    ,1    "
      BITFLD.LONG 0x20 22. "   pd_pub_sys_force_shutdown    , apb reg" "0    ,1    "
      BITFLD.LONG 0x20 23. "   pd_pub_sys_state[0]     , power state" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 24. "   pd_pub_sys_state[1]     , power state" "0    ,1    "
      BITFLD.LONG 0x20 25. "   pd_pub_sys_state[2]            , power state" "0    ,1    "
      BITFLD.LONG 0x20 26. "   pd_pub_sys_state[3]          , power state" "0    ,1    "
      BITFLD.LONG 0x20 27. "   pd_pub_sys_state[4]     , power state" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x20 28. "   all_sys_pwr_pd          , " "0    ,1    "
      BITFLD.LONG 0x20 29. "   dmc_clk_sel[0]                 , clk sel for ddr clk" "0    ,1    "
      BITFLD.LONG 0x20 30. "   dmc_clk_sel[1]               , clk sel for ddr clk" "0    ,1    "
      BITFLD.LONG 0x20 31. "   ddr_glb_cgm_en_sync     , ddr clk cgm indicator" "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_sram RO"
;-------------------------------------------------
    VARX 0x24 %l DBUS.read(0x00090102)
    TEXTLINE ""
    LINE.LONG 0x24 "chain_aon_sram,chain_aon_sram"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x24 0. "   ext_xtl_comb_pd        , " "0    ,1    "
      BITFLD.LONG 0x24 1. "   ap_xtl_pd              , deep sleep signal through slp_state for xtl" "0    ,1    "
      BITFLD.LONG 0x24 2. "   pubcp_xtl_pd           , deep sleep signal through slp_state for xtl" "0    ,1    "
      BITFLD.LONG 0x24 3. "   wtlcp_xtl_pd           , deep sleep signal through slp_state for xtl" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x24 4. "   ca53_top_pd            , cpu top deep sleep" "0    ,1    "
      BITFLD.LONG 0x24 5. "   arm7_xtl_pd            , deep sleep signal through slp_state for xtl" "0    ,1    "
      BITFLD.LONG 0x24 6. "   all_pll_pd             , all pll power down" "0    ,1    "
      BITFLD.LONG 0x24 7. "   pad_out_chip_sleep     , chip sleep output to pmic" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x24 8. "   pad_in_ext_xtl_en0     , " "0    ,1    "
      BITFLD.LONG 0x24 9. "   pad_in_ext_xtl_en1     , " "0    ,1    "
      BITFLD.LONG 0x24 10. "   pad_in_ext_xtl_en2     , " "0    ,1    "
      BITFLD.LONG 0x24 11. "   pad_in_ext_xtl_en3     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x24 12. "   pad_out_xtl_en         , " "0    ,1    "
      BITFLD.LONG 0x24 13. "   pad_out_xtl_buf_en0    , " "0    ,1    "
      BITFLD.LONG 0x24 14. "   pad_out_xtl_buf_en1    , " "0    ,1    "
      BITFLD.LONG 0x24 15. "   dcxo_lc_deep_sleep     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x24 16. "   aon_sram_pd            , aon sram power down signal" "0    ,1    "
      BITFLD.LONG 0x24 17. "   aon_sram_pd_dly[0]     , aon sram power down signal" "0    ,1    "
      BITFLD.LONG 0x24 18. "   aon_sram_pd_dly[1]     , aon sram power down signal" "0    ,1    "
      BITFLD.LONG 0x24 19. "   aon_sram_pd_dly[2]     , aon sram power down signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x24 20. "   aon_sram_pd_dly[3]     , aon sram power down signal" "0    ,1    "
      BITFLD.LONG 0x24 21. "   aon_sram_pd_dly[4]     , aon sram power down signal" "0    ,1    "
      BITFLD.LONG 0x24 22. "   aon_sram_pd_dly[5]     , aon sram power down signal" "0    ,1    "
      BITFLD.LONG 0x24 23. "   aon_sram_pd_dly[6]     , aon sram power down signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x24 24. "   aon_sram_pd_dly[7]     , aon sram power down signal" "0    ,1    "
      BITFLD.LONG 0x24 25. "   aon_sram_pd_dly[8]     , aon sram power down signal" "0    ,1    "
      BITFLD.LONG 0x24 26. "   aon_sram_pd_dly[9]     , aon sram power down signal" "0    ,1    "
      BITFLD.LONG 0x24 27. "   aon_sram_pd_dly[10]    , aon sram power down signal" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x24 28. "   aon_sram_pd_dly[11]    , aon sram power down signal" "0    ,1    "
      BITFLD.LONG 0x24 29. "   aon_sram_pd_dly[12]    , aon sram power down signal" "0    ,1    "
      BITFLD.LONG 0x24 30. "   aon_sram_pd_dly[13]    , aon sram power down signal" "0    ,1    "
      BITFLD.LONG 0x24 31. "   aon_sram_pd_dly[14]    , aon sram power down signal" "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_pd_ap RO"
;-------------------------------------------------
    VARX 0x28 %l DBUS.read(0x00090103)
    TEXTLINE ""
    LINE.LONG 0x28 "chain_aon_pd_ap,chain_aon_pd_ap"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x28 0. "   ap_light_sleep_req     , light sleep signal before latch" "0    ,1    "
      BITFLD.LONG 0x28 1. "   ap_lslp_sel                   , light sleep enable selection" "0    ,1    "
      BITFLD.LONG 0x28 2. "   ap_auto_lslp_ena            , light sleep enable with auto clr" "0    ,1    "
      BITFLD.LONG 0x28 3. "   ap_lslp_ena             , light sleep enable w/o auto clr" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x28 4. "   ap_wakeup_nirq         , wakeup Int." "0    ,1    "
      BITFLD.LONG 0x28 5. "   ap_cactive_slv_wakeup         , cactive from slave of AP Mtx (to ddr channel)" "0    ,1    "
      BITFLD.LONG 0x28 6. "   ap_force_light_sleep        , " "0    ,1    "
      BITFLD.LONG 0x28 7. "   ap_light_sleep          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x28 8. "   ap_deep_sleep_req      , deep sleep signla before latch" "0    ,1    "
      BITFLD.LONG 0x28 9. "   ap_dslp_ena                   , deep sleep enable" "0    ,1    "
      BITFLD.LONG 0x28 10. "   ap_force_deep_sleep         , " "0    ,1    "
      BITFLD.LONG 0x28 11. "   ap_deep_sleep           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x28 12. "   ap_pwr_pd              , " "0    ,1    "
      BITFLD.LONG 0x28 13. "   pd_ap_sys_auto_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x28 14. "   pd_ap_sys_force_shutdown    , " "0    ,1    "
      BITFLD.LONG 0x28 15. "   pd_ap_sys_deep_sleep    , deep sleep signal for power state control" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x28 16. "   ap_pub_deep_stop       , " "0    ,1    "
      BITFLD.LONG 0x28 17. "   ap_pub_dslp_ena               , " "0    ,1    "
      BITFLD.LONG 0x28 18. "   ap_pub_deep_sleep           , " "0    ,1    "
      BITFLD.LONG 0x28 19. "   ap_doze_sleep_ena       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x28 20. "   ap_doze_sleep          , ap power state" "0    ,1    "
      BITFLD.LONG 0x28 21. "   pd_ap_sys_state[0]            , ap power state" "0    ,1    "
      BITFLD.LONG 0x28 22. "   pd_ap_sys_state[1]          , ap power state" "0    ,1    "
      BITFLD.LONG 0x28 23. "   pd_ap_sys_state[2]      , ap power state" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x28 24. "   pd_ap_sys_state[3]     , ap power state" "0    ,1    "
      BITFLD.LONG 0x28 25. "   pd_ap_sys_state[4]            , ap power state" "0    ,1    "
      BITFLD.LONG 0x28 26. "   ca53_top_light_stop         , cpu light sleep signal" "0    ,1    "
      BITFLD.LONG 0x28 27. "   big_adb400_cactivem     , adb400 cactive signal  master" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x28 28. "   big_adb400_cactives    , adb400 cactive signal  slave" "0    ,1    "
      BITFLD.LONG 0x28 29. "   lit_adb400_cactivem           , adb400 cactive signal  master" "0    ,1    "
      BITFLD.LONG 0x28 30. "   lit_adb400_cactives         , adb400 cactive signal  slave" "0    ,1    "
      BITFLD.LONG 0x28 31. "   ca53_wakeup_nirq        , cpu wakeup Int." "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_pd_wtlcp RO"
;-------------------------------------------------
    VARX 0x2C %l DBUS.read(0x00090104)
    TEXTLINE ""
    LINE.LONG 0x2C "chain_aon_pd_wtlcp,chain_aon_pd_wtlcp"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x2C 0. "   wtlcp_light_sleep_req    , wtlcp light sleep before latch" "0    ,1    "
      BITFLD.LONG 0x2C 1. "   wtlcp_lslp_sel                   , " "0    ,1    "
      BITFLD.LONG 0x2C 2. "   wtlcp_auto_lslp_ena            , " "0    ,1    "
      BITFLD.LONG 0x2C 3. "   wtlcp_lslp_ena             , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x2C 4. "   wtlcp_wakeup_nirq        , " "0    ,1    "
      BITFLD.LONG 0x2C 5. "   wtlcp_cactive_slv_wakeup         , cactive from slave of wtlcp Mtx (to ddr channel)" "0    ,1    "
      BITFLD.LONG 0x2C 6. "   wtlcp_force_light_sleep        , " "0    ,1    "
      BITFLD.LONG 0x2C 7. "   wtlcp_light_sleep          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x2C 8. "   wtlcp_deep_sleep_req     , " "0    ,1    "
      BITFLD.LONG 0x2C 9. "   wtlcp_dslp_ena                   , " "0    ,1    "
      BITFLD.LONG 0x2C 10. "   wtlcp_force_deep_sleep         , " "0    ,1    "
      BITFLD.LONG 0x2C 11. "   wtlcp_deep_sleep           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x2C 12. "   wtlcp_pwr_pd             , " "0    ,1    "
      BITFLD.LONG 0x2C 13. "   pd_wtlcp_sys_auto_shutdown_en    , apb reg for auto shutdown" "0    ,1    "
      BITFLD.LONG 0x2C 14. "   pd_wtlcp_sys_force_shutdown    , apb reg for force shutdown" "0    ,1    "
      BITFLD.LONG 0x2C 15. "   pd_wtlcp_sys_deep_sleep    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x2C 16. "   wtlcp_pub_deep_stop      , " "0    ,1    "
      BITFLD.LONG 0x2C 17. "   wtlcp_pub_dslp_ena               , " "0    ,1    "
      BITFLD.LONG 0x2C 18. "   wtlcp_pub_deep_sleep           , " "0    ,1    "
      BITFLD.LONG 0x2C 19. "   wtlcp_doze_sleep_ena       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x2C 20. "   wtlcp_doze_sleep         , " "0    ,1    "
      BITFLD.LONG 0x2C 21. "   pd_wtlcp_sys_state[0]            , wtlcp_sys power state" "0    ,1    "
      BITFLD.LONG 0x2C 22. "   pd_wtlcp_sys_state[1]          , wtlcp_sys power state" "0    ,1    "
      BITFLD.LONG 0x2C 23. "   pd_wtlcp_sys_state[2]      , wtlcp_sys power state" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x2C 24. "   pd_wtlcp_sys_state[3]    , wtlcp_sys power state" "0    ,1    "
      BITFLD.LONG 0x2C 25. "   pd_wtlcp_sys_state[4]            , wtlcp_sys power state" "0    ,1    "
      BITFLD.LONG 0x2C 26.--31. "   reserved                       , " "0    ,1    "
    SGROUP "AON @ chain_aon_pd_pubcp RO"
;-------------------------------------------------
    VARX 0x30 %l DBUS.read(0x00090105)
    TEXTLINE ""
    LINE.LONG 0x30 "chain_aon_pd_pubcp,chain_aon_pd_pubcp"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x30 0. "   pubcp_light_sleep_req           , " "0    ,1    "
      BITFLD.LONG 0x30 1. "   pubcp_lslp_sel                   , " "0    ,1    "
      BITFLD.LONG 0x30 2. "   pubcp_auto_lslp_ena            , " "0    ,1    "
      BITFLD.LONG 0x30 3. "   pubcp_lslp_ena           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x30 4. "   pubcp_wakeup_nirq               , " "0    ,1    "
      BITFLD.LONG 0x30 5. "   pubcp_cactive_slv_wakeup         , " "0    ,1    "
      BITFLD.LONG 0x30 6. "   pubcp_force_light_sleep        , " "0    ,1    "
      BITFLD.LONG 0x30 7. "   pubcp_light_sleep        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x30 8. "   pubcp_deep_sleep_req            , " "0    ,1    "
      BITFLD.LONG 0x30 9. "   pubcp_dslp_ena                   , " "0    ,1    "
      BITFLD.LONG 0x30 10. "   pubcp_force_deep_sleep         , " "0    ,1    "
      BITFLD.LONG 0x30 11. "   pubcp_deep_sleep         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x30 12. "   pubcp_pwr_pd                    , " "0    ,1    "
      BITFLD.LONG 0x30 13. "   pd_pubcp_sys_auto_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x30 14. "   pd_pubcp_sys_force_shutdown    , " "0    ,1    "
      BITFLD.LONG 0x30 15. "   pubcp_dbgnopwrdwn        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x30 16. "   pd_pubcp_sys_dbg_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x30 17. "   pd_pubcp_sys_deep_sleep          , " "0    ,1    "
      BITFLD.LONG 0x30 18. "   pubcp_pub_deep_stop            , " "0    ,1    "
      BITFLD.LONG 0x30 19. "   pubcp_pub_dslp_ena       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x30 20. "   pubcp_pub_deep_sleep            , " "0    ,1    "
      BITFLD.LONG 0x30 21. "   pubcp_doze_sleep_ena             , " "0    ,1    "
      BITFLD.LONG 0x30 22. "   pubcp_doze_sleep               , " "0    ,1    "
      BITFLD.LONG 0x30 23. "   pd_pubcp_sys_state[0]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x30 24. "   pd_pubcp_sys_state[1]           , " "0    ,1    "
      BITFLD.LONG 0x30 25. "   pd_pubcp_sys_state[2]            , " "0    ,1    "
      BITFLD.LONG 0x30 26. "   pd_pubcp_sys_state[3]          , " "0    ,1    "
      BITFLD.LONG 0x30 27. "   pd_pubcp_sys_state[4]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x30 28.--31. "   reserved                        , " "0    ,1    "
    SGROUP "AON @ chain_aon_mem RO"
;-------------------------------------------------
    VARX 0x34 %l DBUS.read(0x00090106)
    TEXTLINE ""
    LINE.LONG 0x34 "chain_aon_mem,chain_aon_mem"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x34 0. "   dbg_mem_sd            , " "0    ,1    "
      BITFLD.LONG 0x34 1. "   dbg_mem_slp           , " "0    ,1    "
      BITFLD.LONG 0x34 2. "   aon_mem_sd_aud        , shutdown for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 3. "   aon_mem_sd_vbc        , shutdown for aon memory" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x34 4. "   aon_mem_sd_dma        , shutdown for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 5. "   aon_mem_sd_imc[0]     , shutdown for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 6. "   aon_mem_sd_imc[1]     , shutdown for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 7. "   aon_mem_sd_imc[2]     , shutdown for aon memory" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x34 8. "   aon_mem_sd_imc[3]     , shutdown for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 9. "   aon_mem_sd_imc[4]     , shutdown for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 10. "   aon_mem_sd_imc[5]     , shutdown for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 11. "   aon_mem_sd_imc[6]     , shutdown for aon memory" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x34 12. "   aon_mem_sd_imc[7]     , shutdown for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 13. "   aon_mem_sd_imc[8]     , shutdown for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 14. "   aon_mem_sd_imc[9]     , shutdown for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 15. "   aon_mem_slp_aud       , sleep for aon memory" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x34 16. "   aon_mem_slp_vbc       , sleep for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 17. "   aon_mem_slp_dma       , sleep for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 18. "   aon_mem_slp_imc[0]    , sleep for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 19. "   aon_mem_slp_imc[1]    , sleep for aon memory" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x34 20. "   aon_mem_slp_imc[2]    , sleep for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 21. "   aon_mem_slp_imc[3]    , sleep for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 22. "   aon_mem_slp_imc[4]    , sleep for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 23. "   aon_mem_slp_imc[5]    , sleep for aon memory" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x34 24. "   aon_mem_slp_imc[6]    , sleep for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 25. "   aon_mem_slp_imc[7]    , sleep for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 26. "   aon_mem_slp_imc[8]    , sleep for aon memory" "0    ,1    "
      BITFLD.LONG 0x34 27. "   aon_mem_slp_imc[9]    , sleep for aon memory" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x34 28.--31. "   reserved              , " "0    ,1    "
    SGROUP "AON @ chain_aon_xtl RO"
;-------------------------------------------------
    VARX 0x38 %l DBUS.read(0x00090107)
    TEXTLINE ""
    LINE.LONG 0x38 "chain_aon_xtl,chain_aon_xtl"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x38 0. "   xtlbuf0_pd              , pll power down" "0    ,1    "
      BITFLD.LONG 0x38 1. "   xtlbuf1_pd          , pll power down" "0    ,1    "
      BITFLD.LONG 0x38 2. "   mpll_pd                   , pll power down" "0    ,1    "
      BITFLD.LONG 0x38 3. "   rpll_pd                , pll power down" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x38 4. "   dpll_pd                 , pll power down" "0    ,1    "
      BITFLD.LONG 0x38 5. "   twpll_pd            , pll power down" "0    ,1    "
      BITFLD.LONG 0x38 6. "   ltepll_pd                 , pll power down" "0    ,1    "
      BITFLD.LONG 0x38 7. "   lvdsdis_pll_pd         , pll power down" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x38 8. "   gpll_pd                 , pll power down" "0    ,1    "
      BITFLD.LONG 0x38 9. "   xtl0_pd             , pll power down" "0    ,1    "
      BITFLD.LONG 0x38 10. "   xtl1_pd                   , pll power down" "0    ,1    "
      BITFLD.LONG 0x38 11. "   rc0_pd                 , pll power down" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x38 12. "   rc1_pd                  , pll power down" "0    ,1    "
      BITFLD.LONG 0x38 13. "   xtlbuf0_cnt_done    , pll  wait stable indicator" "0    ,1    "
      BITFLD.LONG 0x38 14. "   xtlbuf1_cnt_done          , pll  wait stable indicator" "0    ,1    "
      BITFLD.LONG 0x38 15. "   mpll_cnt_done          , pll  wait stable indicator" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x38 16. "   rpll_cnt_done           , pll  wait stable indicator" "0    ,1    "
      BITFLD.LONG 0x38 17. "   dpll_cnt_done       , pll  wait stable indicator" "0    ,1    "
      BITFLD.LONG 0x38 18. "   twpll_cnt_done            , pll  wait stable indicator" "0    ,1    "
      BITFLD.LONG 0x38 19. "   ltepll_cnt_done        , pll  wait stable indicator" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x38 20. "   lvdsdis_pll_cnt_done    , pll  wait stable indicator" "0    ,1    "
      BITFLD.LONG 0x38 21. "   gpll_cnt_done       , pll  wait stable indicator" "0    ,1    "
      BITFLD.LONG 0x38 22. "   xtl0_cnt_done             , pll  wait stable indicator" "0    ,1    "
      BITFLD.LONG 0x38 23. "   xtl1_cnt_done          , pll  wait stable indicator" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x38 24. "   rc0_cnt_done            , pll  wait stable indicator" "0    ,1    "
      BITFLD.LONG 0x38 25. "   rc1_cnt_done        , pll  wait stable indicator" "0    ,1    "
      BITFLD.LONG 0x38 26. "   cppll_pd                  , " "0    ,1    "
      BITFLD.LONG 0x38 27. "   cppll_cnt_done         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x38 28. "   bmpll_pd                , " "0    ,1    "
      BITFLD.LONG 0x38 29. "   bmpll_cnt_done      , " "0    ,1    "
      BITFLD.LONG 0x38 30. "   efuse_pwon_rd_end_flag    , " "0    ,1    "
      BITFLD.LONG 0x38 31. "   efuse_pwon_cnt_done    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_pd_ca53 RO"
;-------------------------------------------------
    VARX 0x3C %l DBUS.read(0x00090108)
    TEXTLINE ""
    LINE.LONG 0x3C "chain_aon_pd_ca53,chain_aon_pd_ca53"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x3C 0. "   ca53_lit_c0_deep_stop           , cpu lit core0 deep sleep before latch" "0    ,1    "
      BITFLD.LONG 0x3C 1. "   ca53_lit_c1_deep_stop         , cpu lit core1 deep sleep before latch" "0    ,1    "
      BITFLD.LONG 0x3C 2. "   ca53_big_c0_deep_stop          , cpu big core0 deep sleep before latch" "0    ,1    "
      BITFLD.LONG 0x3C 3. "   ca53_big_c1_deep_stop         , cpu big core1 deep sleep before latch" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x3C 4. "   ca53_lit_l2_deep_stop           , " "0    ,1    "
      BITFLD.LONG 0x3C 5. "   ca53_big_l2_deep_stop         , " "0    ,1    "
      BITFLD.LONG 0x3C 6. "   pd_ca53_top_deep_sleep         , deep sleep signal for power state control" "0    ,1    "
      BITFLD.LONG 0x3C 7. "   pd_ca53_big_mp2_deep_sleep    , deep sleep signal for power state control" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x3C 8. "   pd_ca53_lit_mp2_deep_sleep      , deep sleep signal for power state control" "0    ,1    "
      BITFLD.LONG 0x3C 9. "   pd_ca53_lit_c0_deep_sleep     , deep sleep signal for power state control" "0    ,1    "
      BITFLD.LONG 0x3C 10. "   pd_ca53_lit_c1_deep_sleep      , deep sleep signal for power state control" "0    ,1    "
      BITFLD.LONG 0x3C 11. "   pd_ca53_big_c0_deep_sleep     , deep sleep signal for power state control" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x3C 12. "   pd_ca53_big_c1_deep_sleep       , deep sleep signal for power state control" "0    ,1    "
      BITFLD.LONG 0x3C 13. "   ca53_top_dslp_ena             , " "0    ,1    "
      BITFLD.LONG 0x3C 14. "   ca53_wakeup_nirq               , " "0    ,1    "
      BITFLD.LONG 0x3C 15. "   gpu_clock_en                  , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x3C 16. "   pd_ap_sys_deep_sleep            , " "0    ,1    "
      BITFLD.LONG 0x3C 17. "   ap_pwr_pd                     , " "0    ,1    "
      BITFLD.LONG 0x3C 18. "   pd_ca53_top_state[0]           , " "0    ,1    "
      BITFLD.LONG 0x3C 19. "   pd_ca53_top_state[1]          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x3C 20. "   pd_ca53_top_state[2]            , " "0    ,1    "
      BITFLD.LONG 0x3C 21. "   pd_ca53_top_state[3]          , " "0    ,1    "
      BITFLD.LONG 0x3C 22. "   pd_ca53_top_state[4]           , " "0    ,1    "
      BITFLD.LONG 0x3C 23. "   ca53_top_deep_sleep_out       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x3C 24. "   pd_ca53_top_auto_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x3C 25. "   pd_ca53_top_force_shutdown    , " "0    ,1    "
      BITFLD.LONG 0x3C 26. "   pd_ca53_top_dbg_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x3C 27. "   pd_ca53_top_pd_sel            , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x3C 28. "   pd_ca53_big_mp2_cgm_en          , " "0    ,1    "
      BITFLD.LONG 0x3C 29. "   pd_ca53_lit_mp2_cgm_en        , " "0    ,1    "
      BITFLD.LONG 0x3C 30. "   pd_ca53_top_cgm_en             , " "0    ,1    "
      BITFLD.LONG 0x3C 31. "   ca53_top_light_stop           , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_pd_ca53_lit RO"
;-------------------------------------------------
    VARX 0x40 %l DBUS.read(0x00090109)
    TEXTLINE ""
    LINE.LONG 0x40 "chain_aon_pd_ca53_lit,chain_aon_pd_ca53_lit"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x40 0. "   ca53_lit_c0_deep_stop           , " "0    ,1    "
      BITFLD.LONG 0x40 1. "   ca53_lit_c0_dslp_ena               , " "0    ,1    "
      BITFLD.LONG 0x40 2. "   ca53_wakeup_nirq                    , " "0    ,1    "
      BITFLD.LONG 0x40 3. "   ca53_lit_c0_wakeup_en             , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x40 4. "   ca53_lit_c0_core_int_disable    , " "0    ,1    "
      BITFLD.LONG 0x40 5. "   ca53_lit_c0_deep_sleep_out         , " "0    ,1    "
      BITFLD.LONG 0x40 6. "   pd_ca53_lit_c0_pd_sel               , " "0    ,1    "
      BITFLD.LONG 0x40 7. "   ap_pwr_pd                         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x40 8. "   pd_ca53_lit_c0_deep_sleep       , " "0    ,1    "
      BITFLD.LONG 0x40 9. "   pd_ca53_lit_c0_auto_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x40 10. "   pd_ca53_lit_c0_force_shutdown       , " "0    ,1    "
      BITFLD.LONG 0x40 11. "   pd_ca53_lit_c0_dbg_shutdown_en    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x40 12. "   ca53_lit_dbgnopwrdwn[0]         , " "0    ,1    "
      BITFLD.LONG 0x40 13. "   ca53_lit_dbgpwrupreq[0]            , " "0    ,1    "
      BITFLD.LONG 0x40 14. "   pd_ca53_lit_mp2_auto_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x40 15. "   pd_ca53_lit_mp2_force_shutdown    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x40 16. "   pd_ca53_top_auto_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x40 17. "   pd_ca53_top_force_shutdown         , " "0    ,1    "
      BITFLD.LONG 0x40 18. "   pd_ca53_lit_c0_state[0]             , " "0    ,1    "
      BITFLD.LONG 0x40 19. "   pd_ca53_lit_c0_state[1]           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x40 20. "   pd_ca53_lit_c0_state[2]         , " "0    ,1    "
      BITFLD.LONG 0x40 21. "   pd_ca53_lit_c0_state[3]            , " "0    ,1    "
      BITFLD.LONG 0x40 22. "   pd_ca53_lit_c0_state[4]             , " "0    ,1    "
      BITFLD.LONG 0x40 23. "   ca53_lit_core_gic_rst_en          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x40 24. "   ca53_gic_irqout[0]              , " "0    ,1    "
      BITFLD.LONG 0x40 25. "   ca53_gic_fiqout[0]                 , " "0    ,1    "
      BITFLD.LONG 0x40 26. "   ca53_lit_l2standbywfi               , " "0    ,1    "
      BITFLD.LONG 0x40 27. "   ca53_lit_standbywfi[0]            , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x40 28.--31. "   reserved                        , " "0    ,1    "
    SGROUP "AON @ chain_aon_pd_ca53_lit1 RO"
;-------------------------------------------------
    VARX 0x44 %l DBUS.read(0x0009010A)
    TEXTLINE ""
    LINE.LONG 0x44 "chain_aon_pd_ca53_lit1,chain_aon_pd_ca53_lit1"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x44 0. "   ca53_lit_c1_deep_stop           , " "0    ,1    "
      BITFLD.LONG 0x44 1. "   ca53_lit_c1_dslp_ena               , " "0    ,1    "
      BITFLD.LONG 0x44 2. "   ca53_wakeup_nirq                    , " "0    ,1    "
      BITFLD.LONG 0x44 3. "   ca53_lit_c1_wakeup_en             , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x44 4. "   ca53_lit_c1_core_int_disable    , " "0    ,1    "
      BITFLD.LONG 0x44 5. "   ca53_lit_c1_deep_sleep_out         , " "0    ,1    "
      BITFLD.LONG 0x44 6. "   pd_ca53_lit_c1_pd_sel               , " "0    ,1    "
      BITFLD.LONG 0x44 7. "   ap_pwr_pd                         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x44 8. "   pd_ca53_lit_c1_deep_sleep       , " "0    ,1    "
      BITFLD.LONG 0x44 9. "   pd_ca53_lit_c1_auto_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x44 10. "   pd_ca53_lit_c1_force_shutdown       , " "0    ,1    "
      BITFLD.LONG 0x44 11. "   pd_ca53_lit_c1_dbg_shutdown_en    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x44 12. "   ca53_lit_dbgnopwrdwn[1]         , " "0    ,1    "
      BITFLD.LONG 0x44 13. "   ca53_lit_dbgpwrupreq[1]            , " "0    ,1    "
      BITFLD.LONG 0x44 14. "   pd_ca53_lit_mp2_auto_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x44 15. "   pd_ca53_lit_mp2_force_shutdown    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x44 16. "   pd_ca53_top_auto_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x44 17. "   pd_ca53_top_force_shutdown         , " "0    ,1    "
      BITFLD.LONG 0x44 18. "   pd_ca53_lit_c1_state[0]             , " "0    ,1    "
      BITFLD.LONG 0x44 19. "   pd_ca53_lit_c1_state[1]           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x44 20. "   pd_ca53_lit_c1_state[2]         , " "0    ,1    "
      BITFLD.LONG 0x44 21. "   pd_ca53_lit_c1_state[3]            , " "0    ,1    "
      BITFLD.LONG 0x44 22. "   pd_ca53_lit_c1_state[4]             , " "0    ,1    "
      BITFLD.LONG 0x44 23. "   ca53_lit_core_gic_rst_en          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x44 24. "   ca53_gic_irqout[1]              , " "0    ,1    "
      BITFLD.LONG 0x44 25. "   ca53_gic_fiqout[1]                 , " "0    ,1    "
      BITFLD.LONG 0x44 26. "   pd_ca53_lit_c1_bond_off             , " "0    ,1    "
      BITFLD.LONG 0x44 27. "   ca53_lit_standbywfi[1]            , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x44 28.--31. "   reserved                        , " "0    ,1    "
    SGROUP "AON @ chain_aon_pd_ca53_big RO"
;-------------------------------------------------
    VARX 0x48 %l DBUS.read(0x0009010B)
    TEXTLINE ""
    LINE.LONG 0x48 "chain_aon_pd_ca53_big,chain_aon_pd_ca53_big"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x48 0. "   ca53_big_c0_deep_stop               , " "0    ,1    "
      BITFLD.LONG 0x48 1. "   jvl_c0_dslp_ena[0]                , " "0    ,1    "
      BITFLD.LONG 0x48 2. "   jvl_c0_dslp_ena[1]              , " "0    ,1    "
      BITFLD.LONG 0x48 3. "   ca53_wakeup_nirq                   , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x48 4. "   ca53_big_c0_wakeup_en               , " "0    ,1    "
      BITFLD.LONG 0x48 5. "   jvl_c0_int_disable[0]             , " "0    ,1    "
      BITFLD.LONG 0x48 6. "   jvl_c0_int_disable[1]           , " "0    ,1    "
      BITFLD.LONG 0x48 7. "   ca53_big_c0_deep_sleep_out         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x48 8. "   pd_ca53_big_c0_pd_sel               , " "0    ,1    "
      BITFLD.LONG 0x48 9. "   ap_pwr_pd                         , " "0    ,1    "
      BITFLD.LONG 0x48 10. "   pd_ca53_big_c0_deep_sleep       , " "0    ,1    "
      BITFLD.LONG 0x48 11. "   pd_ca53_big_c0_auto_shutdown_en    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x48 12. "   pd_ca53_big_c0_force_shutdown       , " "0    ,1    "
      BITFLD.LONG 0x48 13. "   pd_ca53_big_c0_dbg_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x48 14. "   ca53_big_dbgnopwrdwn[0]         , " "0    ,1    "
      BITFLD.LONG 0x48 15. "   ca53_big_dbgpwrupreq[0]            , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x48 16. "   pd_ca53_big_mp2_auto_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x48 17. "   pd_ca53_big_mp2_force_shutdown    , " "0    ,1    "
      BITFLD.LONG 0x48 18. "   pd_ca53_top_auto_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x48 19. "   pd_ca53_top_force_shutdown         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x48 20. "   pd_ca53_big_c0_state[0]             , " "0    ,1    "
      BITFLD.LONG 0x48 21. "   pd_ca53_big_c0_state[1]           , " "0    ,1    "
      BITFLD.LONG 0x48 22. "   pd_ca53_big_c0_state[2]         , " "0    ,1    "
      BITFLD.LONG 0x48 23. "   pd_ca53_big_c0_state[3]            , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x48 24. "   pd_ca53_big_c0_state[4]             , " "0    ,1    "
      BITFLD.LONG 0x48 25. "   ca53_big_core_gic_rst_en          , " "0    ,1    "
      BITFLD.LONG 0x48 26. "   ca53_gic_irqout[2]              , " "0    ,1    "
      BITFLD.LONG 0x48 27. "   ca53_gic_fiqout[2]                 , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x48 28. "   ca53_gic_irqout[3]                  , " "0    ,1    "
      BITFLD.LONG 0x48 29. "   ca53_gic_fiqout[3]                , " "0    ,1    "
      BITFLD.LONG 0x48 30. "   ca53_big_l2standbywfi           , " "0    ,1    "
      BITFLD.LONG 0x48 31. "   ca53_big_standbywfi[0]             , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_pd_ca53_big1 RO"
;-------------------------------------------------
    VARX 0x4C %l DBUS.read(0x0009010C)
    TEXTLINE ""
    LINE.LONG 0x4C "chain_aon_pd_ca53_big1,chain_aon_pd_ca53_big1"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x4C 0. "   ca53_big_c1_deep_stop               , " "0    ,1    "
      BITFLD.LONG 0x4C 1. "   jvl_c1_dslp_ena[0]                , " "0    ,1    "
      BITFLD.LONG 0x4C 2. "   jvl_c1_dslp_ena[1]              , " "0    ,1    "
      BITFLD.LONG 0x4C 3. "   ca53_wakeup_nirq                   , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x4C 4. "   ca53_big_c1_wakeup_en               , " "0    ,1    "
      BITFLD.LONG 0x4C 5. "   jvl_c1_int_disable[0]             , " "0    ,1    "
      BITFLD.LONG 0x4C 6. "   jvl_c1_int_disable[1]           , " "0    ,1    "
      BITFLD.LONG 0x4C 7. "   ca53_big_c1_deep_sleep_out         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x4C 8. "   pd_ca53_big_c1_pd_sel               , " "0    ,1    "
      BITFLD.LONG 0x4C 9. "   ap_pwr_pd                         , " "0    ,1    "
      BITFLD.LONG 0x4C 10. "   pd_ca53_big_c1_deep_sleep       , " "0    ,1    "
      BITFLD.LONG 0x4C 11. "   pd_ca53_big_c1_auto_shutdown_en    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x4C 12. "   pd_ca53_big_c1_force_shutdown       , " "0    ,1    "
      BITFLD.LONG 0x4C 13. "   pd_ca53_big_c1_dbg_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x4C 14. "   ca53_big_dbgnopwrdwn[1]         , " "0    ,1    "
      BITFLD.LONG 0x4C 15. "   ca53_big_dbgpwrupreq[1]            , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x4C 16. "   pd_ca53_big_mp2_auto_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x4C 17. "   pd_ca53_big_mp2_force_shutdown    , " "0    ,1    "
      BITFLD.LONG 0x4C 18. "   pd_ca53_top_auto_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x4C 19. "   pd_ca53_top_force_shutdown         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x4C 20. "   pd_ca53_big_c1_state[0]             , " "0    ,1    "
      BITFLD.LONG 0x4C 21. "   pd_ca53_big_c1_state[1]           , " "0    ,1    "
      BITFLD.LONG 0x4C 22. "   pd_ca53_big_c1_state[2]         , " "0    ,1    "
      BITFLD.LONG 0x4C 23. "   pd_ca53_big_c1_state[3]            , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x4C 24. "   pd_ca53_big_c1_state[4]             , " "0    ,1    "
      BITFLD.LONG 0x4C 25. "   ca53_big_core_gic_rst_en          , " "0    ,1    "
      BITFLD.LONG 0x4C 26. "   ca53_gic_irqout[4]              , " "0    ,1    "
      BITFLD.LONG 0x4C 27. "   ca53_gic_fiqout[4]                 , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x4C 28. "   ca53_gic_irqout[5]                  , " "0    ,1    "
      BITFLD.LONG 0x4C 29. "   ca53_gic_fiqout[5]                , " "0    ,1    "
      BITFLD.LONG 0x4C 30. "   pd_ca53_big_c1_bond_off         , " "0    ,1    "
      BITFLD.LONG 0x4C 31. "   ca53_big_standbywfi[1]             , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_pd_lte RO"
;-------------------------------------------------
    VARX 0x50 %l DBUS.read(0x0009010D)
    TEXTLINE ""
    LINE.LONG 0x50 "chain_aon_pd_lte,chain_aon_pd_lte"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x50 0. "   pd_wtlcp_tgdsp_wakeup_lock    , " "0    ,1    "
      BITFLD.LONG 0x50 1. "   pd_wtlcp_ldsp_wakeup_lock    , " "0    ,1    "
      BITFLD.LONG 0x50 2. "   pd_wtlcp_td_state[0]        , " "0    ,1    "
      BITFLD.LONG 0x50 3. "   pd_wtlcp_td_state[1]        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x50 4. "   pd_wtlcp_td_state[2]          , " "0    ,1    "
      BITFLD.LONG 0x50 5. "   pd_wtlcp_td_state[3]         , " "0    ,1    "
      BITFLD.LONG 0x50 6. "   pd_wtlcp_td_state[4]        , " "0    ,1    "
      BITFLD.LONG 0x50 7. "   pd_wtlcp_lte_p1_state[0]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x50 8. "   pd_wtlcp_lte_p1_state[1]      , " "0    ,1    "
      BITFLD.LONG 0x50 9. "   pd_wtlcp_lte_p1_state[2]     , " "0    ,1    "
      BITFLD.LONG 0x50 10. "   pd_wtlcp_lte_p1_state[3]    , " "0    ,1    "
      BITFLD.LONG 0x50 11. "   pd_wtlcp_lte_p1_state[4]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x50 12. "   pd_wtlcp_lte_p2_state[0]      , " "0    ,1    "
      BITFLD.LONG 0x50 13. "   pd_wtlcp_lte_p2_state[1]     , " "0    ,1    "
      BITFLD.LONG 0x50 14. "   pd_wtlcp_lte_p2_state[2]    , " "0    ,1    "
      BITFLD.LONG 0x50 15. "   pd_wtlcp_lte_p2_state[3]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x50 16. "   pd_wtlcp_lte_p2_state[4]      , " "0    ,1    "
      BITFLD.LONG 0x50 17. "   pd_wtlcp_lte_p3_state[0]     , " "0    ,1    "
      BITFLD.LONG 0x50 18. "   pd_wtlcp_lte_p3_state[1]    , " "0    ,1    "
      BITFLD.LONG 0x50 19. "   pd_wtlcp_lte_p3_state[2]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x50 20. "   pd_wtlcp_lte_p3_state[3]      , " "0    ,1    "
      BITFLD.LONG 0x50 21. "   pd_wtlcp_lte_p3_state[4]     , " "0    ,1    "
      BITFLD.LONG 0x50 22. "   pd_wtlcp_lte_p4_state[0]    , " "0    ,1    "
      BITFLD.LONG 0x50 23. "   pd_wtlcp_lte_p4_state[1]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x50 24. "   pd_wtlcp_lte_p4_state[2]      , " "0    ,1    "
      BITFLD.LONG 0x50 25. "   pd_wtlcp_lte_p4_state[3]     , " "0    ,1    "
      BITFLD.LONG 0x50 26. "   pd_wtlcp_lte_p4_state[4]    , " "0    ,1    "
      BITFLD.LONG 0x50 27. "   pd_wtlcp_sys_state[0]       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x50 28. "   pd_wtlcp_sys_state[1]         , " "0    ,1    "
      BITFLD.LONG 0x50 29. "   pd_wtlcp_sys_state[2]        , " "0    ,1    "
      BITFLD.LONG 0x50 30. "   pd_wtlcp_sys_state[3]       , " "0    ,1    "
      BITFLD.LONG 0x50 31. "   pd_wtlcp_sys_state[4]       , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_pd_ldsp RO"
;-------------------------------------------------
    VARX 0x54 %l DBUS.read(0x0009010E)
    TEXTLINE ""
    LINE.LONG 0x54 "chain_aon_pd_ldsp,chain_aon_pd_ldsp"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x54 0. "   wtlcp_tgdsp_deep_sleep_req         , " "0    ,1    "
      BITFLD.LONG 0x54 1. "   wtlcp_tgdsp_dslp_ena             , " "0    ,1    "
      BITFLD.LONG 0x54 2. "   wtlcp_pwr_pd                 , " "0    ,1    "
      BITFLD.LONG 0x54 3. "   wtlcp_tgdsp_wakeup_nirq           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x54 4. "   wtlcp_tgdsp_core_int_disable       , " "0    ,1    "
      BITFLD.LONG 0x54 5. "   wtlcp_tgdsp_deep_sleep_out       , " "0    ,1    "
      BITFLD.LONG 0x54 6. "   pd_wtlcp_tgdsp_pd_sel        , " "0    ,1    "
      BITFLD.LONG 0x54 7. "   pd_wtlcp_tgdsp_shutdown           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x54 8. "   pd_wtlcp_tgdsp_auto_shutdown_en    , " "0    ,1    "
      BITFLD.LONG 0x54 9. "   pd_wtlcp_tgdsp_force_shutdown    , " "0    ,1    "
      BITFLD.LONG 0x54 10. "   pd_wtlcp_tgdsp_deep_sleep    , " "0    ,1    "
      BITFLD.LONG 0x54 11. "   pd_wtlcp_tgdsp_state[0]           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x54 12. "   pd_wtlcp_tgdsp_state[1]            , " "0    ,1    "
      BITFLD.LONG 0x54 13. "   pd_wtlcp_tgdsp_state[2]          , " "0    ,1    "
      BITFLD.LONG 0x54 14. "   pd_wtlcp_tgdsp_state[3]      , " "0    ,1    "
      BITFLD.LONG 0x54 15. "   pd_wtlcp_tgdsp_state[4]           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x54 16. "   wtlcp_ldsp_deep_sleep_req          , " "0    ,1    "
      BITFLD.LONG 0x54 17. "   wtlcp_ldsp_dslp_ena              , " "0    ,1    "
      BITFLD.LONG 0x54 18. "   wtlcp_ldsp_wakeup_nirq       , " "0    ,1    "
      BITFLD.LONG 0x54 19. "   wtlcp_ldsp_core_int_disable       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x54 20. "   wtlcp_ldsp_deep_sleep_out          , " "0    ,1    "
      BITFLD.LONG 0x54 21. "   pd_wtlcp_ldsp_pd_sel             , " "0    ,1    "
      BITFLD.LONG 0x54 22. "   pd_wtlcp_ldsp_shutdown       , " "0    ,1    "
      BITFLD.LONG 0x54 23. "   pd_wtlcp_ldsp_auto_shutdown_en    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x54 24. "   pd_wtlcp_ldsp_force_shutdown       , " "0    ,1    "
      BITFLD.LONG 0x54 25. "   pd_wtlcp_ldsp_deep_sleep         , " "0    ,1    "
      BITFLD.LONG 0x54 26. "   pd_wtlcp_ldsp_state[0]       , " "0    ,1    "
      BITFLD.LONG 0x54 27. "   pd_wtlcp_ldsp_state[1]            , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x54 28. "   pd_wtlcp_ldsp_state[2]             , " "0    ,1    "
      BITFLD.LONG 0x54 29. "   pd_wtlcp_ldsp_state[3]           , " "0    ,1    "
      BITFLD.LONG 0x54 30. "   pd_wtlcp_ldsp_state[4]       , " "0    ,1    "
      BITFLD.LONG 0x54 31. "   reserved                          , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_pd_gpu_top RO"
;-------------------------------------------------
    VARX 0x58 %l DBUS.read(0x0009010F)
    TEXTLINE ""
    LINE.LONG 0x58 "chain_aon_pd_gpu_top,chain_aon_pd_gpu_top"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x58 0. "   pd_gpu_top_state[0]         , " "0    ,1    "
      BITFLD.LONG 0x58 1. "   pd_gpu_top_state[1]         , " "0    ,1    "
      BITFLD.LONG 0x58 2. "   pd_gpu_top_state[2]         , " "0    ,1    "
      BITFLD.LONG 0x58 3. "   pd_gpu_top_state[3]         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x58 4. "   pd_gpu_top_state[4]         , " "0    ,1    "
      BITFLD.LONG 0x58 5. "   pd_mm_top_state[0]          , " "0    ,1    "
      BITFLD.LONG 0x58 6. "   pd_mm_top_state[1]          , " "0    ,1    "
      BITFLD.LONG 0x58 7. "   pd_mm_top_state[2]          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x58 8. "   pd_mm_top_state[3]          , " "0    ,1    "
      BITFLD.LONG 0x58 9. "   pd_mm_top_state[4]          , " "0    ,1    "
      BITFLD.LONG 0x58 10. "   pd_ca53_big_mp2_state[0]    , " "0    ,1    "
      BITFLD.LONG 0x58 11. "   pd_ca53_big_mp2_state[1]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x58 12. "   pd_ca53_big_mp2_state[2]    , " "0    ,1    "
      BITFLD.LONG 0x58 13. "   pd_ca53_big_mp2_state[3]    , " "0    ,1    "
      BITFLD.LONG 0x58 14. "   pd_ca53_big_mp2_state[4]    , " "0    ,1    "
      BITFLD.LONG 0x58 15. "   pd_ca53_lit_mp2_state[0]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x58 16. "   pd_ca53_lit_mp2_state[1]    , " "0    ,1    "
      BITFLD.LONG 0x58 17. "   pd_ca53_lit_mp2_state[2]    , " "0    ,1    "
      BITFLD.LONG 0x58 18. "   pd_ca53_lit_mp2_state[3]    , " "0    ,1    "
      BITFLD.LONG 0x58 19. "   pd_ca53_lit_mp2_state[4]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x58 20. "   pd_ca53_top_state[0]        , " "0    ,1    "
      BITFLD.LONG 0x58 21. "   pd_ca53_top_state[1]        , " "0    ,1    "
      BITFLD.LONG 0x58 22. "   pd_ca53_top_state[2]        , " "0    ,1    "
      BITFLD.LONG 0x58 23. "   pd_ca53_top_state[3]        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x58 24. "   pd_ca53_top_state[4]        , " "0    ,1    "
      BITFLD.LONG 0x58 25. "   pd_ap_sys_state[0]          , " "0    ,1    "
      BITFLD.LONG 0x58 26. "   pd_ap_sys_state[1]          , " "0    ,1    "
      BITFLD.LONG 0x58 27. "   pd_ap_sys_state[2]          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x58 28. "   pd_ap_sys_state[3]          , " "0    ,1    "
      BITFLD.LONG 0x58 29. "   pd_ap_sys_state[4]          , " "0    ,1    "
      BITFLD.LONG 0x58 30.--31. "   reserved                    , " "0    ,1    "
    SGROUP "AON @ chain_aon_pd_ap_sys RO"
;-------------------------------------------------
    VARX 0x5C %l DBUS.read(0x00090110)
    TEXTLINE ""
    LINE.LONG 0x5C "chain_aon_pd_ap_sys,chain_aon_pd_ap_sys"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x5C 0. "   pd_ca53_big_c1_deep_sleep_sync     , " "0    ,1    "
      BITFLD.LONG 0x5C 1. "   pd_ca53_big_c0_deep_sleep_sync     , " "0    ,1    "
      BITFLD.LONG 0x5C 2. "   pd_ca53_lit_c1_deep_sleep_sync    , " "0    ,1    "
      BITFLD.LONG 0x5C 3. "   pd_ca53_lit_c0_deep_sleep_sync    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x5C 4. "   pd_ca53_lit_mp2_deep_sleep_sync    , " "0    ,1    "
      BITFLD.LONG 0x5C 5. "   pd_ca53_big_mp2_deep_sleep_sync    , " "0    ,1    "
      BITFLD.LONG 0x5C 6. "   pd_ca53_top_deep_sleep_sync       , " "0    ,1    "
      BITFLD.LONG 0x5C 7. "   pd_ap_sys_deep_sleep_sync         , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x5C 8. "   ap_sys_big_p4_frc_off              , " "0    ,1    "
      BITFLD.LONG 0x5C 9. "   ap_sys_lit_p4_frc_off              , " "0    ,1    "
      BITFLD.LONG 0x5C 10. "   ap_sys_big_p3_frc_off             , " "0    ,1    "
      BITFLD.LONG 0x5C 11. "   ap_sys_big_p3_frc_on              , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x5C 12. "   ap_sys_lit_p3_frc_off              , " "0    ,1    "
      BITFLD.LONG 0x5C 13. "   ap_sys_lit_p3_frc_on               , " "0    ,1    "
      BITFLD.LONG 0x5C 14. "   ap_sys_big_p2_frc_off             , " "0    ,1    "
      BITFLD.LONG 0x5C 15. "   ap_sys_big_p2_frc_on              , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x5C 16. "   ap_sys_lit_p2_frc_off              , " "0    ,1    "
      BITFLD.LONG 0x5C 17. "   ap_sys_lit_p2_frc_on               , " "0    ,1    "
      BITFLD.LONG 0x5C 18. "   ap_sys_big_p1_frc_off             , " "0    ,1    "
      BITFLD.LONG 0x5C 19. "   ap_sys_big_p1_frc_on              , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x5C 20. "   ap_sys_lit_p1_frc_off              , " "0    ,1    "
      BITFLD.LONG 0x5C 21. "   ap_sys_lit_p1_frc_on               , " "0    ,1    "
      BITFLD.LONG 0x5C 22. "   pd_ca53_top_frc_off               , " "0    ,1    "
      BITFLD.LONG 0x5C 23. "   pd_ca53_top_frc_on                , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x5C 24. "   ap_sys_p1_frc_off                  , " "0    ,1    "
      BITFLD.LONG 0x5C 25. "   ap_sys_p1_frc_on                   , " "0    ,1    "
      BITFLD.LONG 0x5C 26.--31. "   reserved                          , " "0    ,1    "
    SGROUP "AON @ chain_aon_pd_wtlcp_hu3ge RO"
;-------------------------------------------------
    VARX 0x60 %l DBUS.read(0x00090111)
    TEXTLINE ""
    LINE.LONG 0x60 "chain_aon_pd_wtlcp_hu3ge,chain_aon_pd_wtlcp_hu3ge"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x60 0. "   pd_wtlcp_hu3ge_a_state[0]          , " "0    ,1    "
      BITFLD.LONG 0x60 1. "   pd_wtlcp_hu3ge_a_state[1]          , " "0    ,1    "
      BITFLD.LONG 0x60 2. "   pd_wtlcp_hu3ge_a_state[2]           , " "0    ,1    "
      BITFLD.LONG 0x60 3. "   pd_wtlcp_hu3ge_a_state[3]           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x60 4. "   pd_wtlcp_hu3ge_a_state[4]          , " "0    ,1    "
      BITFLD.LONG 0x60 5. "   pd_wtlcp_hu3ge_b_state[0]          , " "0    ,1    "
      BITFLD.LONG 0x60 6. "   pd_wtlcp_hu3ge_b_state[1]           , " "0    ,1    "
      BITFLD.LONG 0x60 7. "   pd_wtlcp_hu3ge_b_state[2]           , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x60 8. "   pd_wtlcp_hu3ge_b_state[3]          , " "0    ,1    "
      BITFLD.LONG 0x60 9. "   pd_wtlcp_hu3ge_b_state[4]          , " "0    ,1    "
      BITFLD.LONG 0x60 10. "   pd_wtlcp_lte_p1_deep_sleep_sync     , " "0    ,1    "
      BITFLD.LONG 0x60 11. "   pd_wtlcp_lte_p2_deep_sleep_sync     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x60 12. "   pd_wtlcp_lte_p3_deep_sleep_sync    , " "0    ,1    "
      BITFLD.LONG 0x60 13. "   pd_wtlcp_lte_p4_deep_sleep_sync    , " "0    ,1    "
      BITFLD.LONG 0x60 14. "   pd_wtlcp_hu3ge_b_deep_sleep_sync    , " "0    ,1    "
      BITFLD.LONG 0x60 15. "   pd_wtlcp_hu3ge_a_deep_sleep_sync    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x60 16. "   pd_wtlcp_tgdsp_deep_sleep_sync     , " "0    ,1    "
      BITFLD.LONG 0x60 17. "   pd_wtlcp_ldsp_deep_sleep_sync      , " "0    ,1    "
      BITFLD.LONG 0x60 18. "   pd_wtlcp_td_deep_sleep_sync         , " "0    ,1    "
      BITFLD.LONG 0x60 19. "   pd_wtlcp_sys_deep_sleep_sync        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x60 20. "   wtlcp_sys_p2_frc_off               , " "0    ,1    "
      BITFLD.LONG 0x60 21. "   wtlcp_sys_p1_frc_off               , " "0    ,1    "
      BITFLD.LONG 0x60 22. "   wtlcp_sys_p1_frc_on                 , " "0    ,1    "
      BITFLD.LONG 0x60 23. "   wtlcp_sys_p2_deep_sleep             , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x60 24. "   wtlcp_sys_p1_deep_sleep            , " "0    ,1    "
      BITFLD.LONG 0x60 25.--31. "   reserved                           , " "0    ,1    "
    SGROUP "AON @ chain_aon_ap_pubcp_light RO"
;-------------------------------------------------
    VARX 0x64 %l DBUS.read(0x00090112)
    TEXTLINE ""
    LINE.LONG 0x64 "chain_aon_ap_pubcp_light,chain_aon_ap_pubcp_light"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x64 0. "   ap_light_sleep_cnt[0]        , light sleep counter" "0    ,1    "
      BITFLD.LONG 0x64 1. "   ap_light_sleep_cnt[1]        , " "0    ,1    "
      BITFLD.LONG 0x64 2. "   ap_light_sleep_cnt[2]        , " "0    ,1    "
      BITFLD.LONG 0x64 3. "   ap_light_sleep_cnt[3]        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x64 4. "   ap_light_sleep_cnt[4]        , " "0    ,1    "
      BITFLD.LONG 0x64 5. "   ap_light_sleep_cnt[5]        , " "0    ,1    "
      BITFLD.LONG 0x64 6. "   ap_light_sleep_cnt[6]        , " "0    ,1    "
      BITFLD.LONG 0x64 7. "   ap_light_sleep_cnt[7]        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x64 8. "   ap_light_sleep_cnt[8]        , " "0    ,1    "
      BITFLD.LONG 0x64 9. "   ap_light_sleep_cnt[9]        , " "0    ,1    "
      BITFLD.LONG 0x64 10. "   ap_light_sleep_cnt[10]       , " "0    ,1    "
      BITFLD.LONG 0x64 11. "   ap_light_sleep_cnt[11]       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x64 12. "   ap_light_sleep_cnt[12]       , " "0    ,1    "
      BITFLD.LONG 0x64 13. "   ap_light_sleep_cnt[13]       , " "0    ,1    "
      BITFLD.LONG 0x64 14. "   ap_light_sleep_cnt[14]       , " "0    ,1    "
      BITFLD.LONG 0x64 15. "   ap_light_sleep_cnt[15]       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x64 16. "   pubcp_light_sleep_cnt[0]     , light sleep counter" "0    ,1    "
      BITFLD.LONG 0x64 17. "   pubcp_light_sleep_cnt[1]     , " "0    ,1    "
      BITFLD.LONG 0x64 18. "   pubcp_light_sleep_cnt[2]     , " "0    ,1    "
      BITFLD.LONG 0x64 19. "   pubcp_light_sleep_cnt[3]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x64 20. "   pubcp_light_sleep_cnt[4]     , " "0    ,1    "
      BITFLD.LONG 0x64 21. "   pubcp_light_sleep_cnt[5]     , " "0    ,1    "
      BITFLD.LONG 0x64 22. "   pubcp_light_sleep_cnt[6]     , " "0    ,1    "
      BITFLD.LONG 0x64 23. "   pubcp_light_sleep_cnt[7]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x64 24. "   pubcp_light_sleep_cnt[8]     , " "0    ,1    "
      BITFLD.LONG 0x64 25. "   pubcp_light_sleep_cnt[9]     , " "0    ,1    "
      BITFLD.LONG 0x64 26. "   pubcp_light_sleep_cnt[10]    , " "0    ,1    "
      BITFLD.LONG 0x64 27. "   pubcp_light_sleep_cnt[11]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x64 28. "   pubcp_light_sleep_cnt[12]    , " "0    ,1    "
      BITFLD.LONG 0x64 29. "   pubcp_light_sleep_cnt[13]    , " "0    ,1    "
      BITFLD.LONG 0x64 30. "   pubcp_light_sleep_cnt[14]    , " "0    ,1    "
      BITFLD.LONG 0x64 31. "   pubcp_light_sleep_cnt[15]    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_pub_wtlcp_light RO"
;-------------------------------------------------
    VARX 0x68 %l DBUS.read(0x00090113)
    TEXTLINE ""
    LINE.LONG 0x68 "chain_aon_pub_wtlcp_light,chain_aon_pub_wtlcp_light"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x68 0. "   wtlcp_light_sleep_cnt[0]     , light sleep counter" "0    ,1    "
      BITFLD.LONG 0x68 1. "   wtlcp_light_sleep_cnt[1]     , " "0    ,1    "
      BITFLD.LONG 0x68 2. "   wtlcp_light_sleep_cnt[2]     , " "0    ,1    "
      BITFLD.LONG 0x68 3. "   wtlcp_light_sleep_cnt[3]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x68 4. "   wtlcp_light_sleep_cnt[4]     , " "0    ,1    "
      BITFLD.LONG 0x68 5. "   wtlcp_light_sleep_cnt[5]     , " "0    ,1    "
      BITFLD.LONG 0x68 6. "   wtlcp_light_sleep_cnt[6]     , " "0    ,1    "
      BITFLD.LONG 0x68 7. "   wtlcp_light_sleep_cnt[7]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x68 8. "   wtlcp_light_sleep_cnt[8]     , " "0    ,1    "
      BITFLD.LONG 0x68 9. "   wtlcp_light_sleep_cnt[9]     , " "0    ,1    "
      BITFLD.LONG 0x68 10. "   wtlcp_light_sleep_cnt[10]    , " "0    ,1    "
      BITFLD.LONG 0x68 11. "   wtlcp_light_sleep_cnt[11]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x68 12. "   wtlcp_light_sleep_cnt[12]    , " "0    ,1    "
      BITFLD.LONG 0x68 13. "   wtlcp_light_sleep_cnt[13]    , " "0    ,1    "
      BITFLD.LONG 0x68 14. "   wtlcp_light_sleep_cnt[14]    , " "0    ,1    "
      BITFLD.LONG 0x68 15. "   wtlcp_light_sleep_cnt[15]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x68 16. "   pub_light_sleep_cnt[0]       , light sleep counter" "0    ,1    "
      BITFLD.LONG 0x68 17. "   pub_light_sleep_cnt[1]       , " "0    ,1    "
      BITFLD.LONG 0x68 18. "   pub_light_sleep_cnt[2]       , " "0    ,1    "
      BITFLD.LONG 0x68 19. "   pub_light_sleep_cnt[3]       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x68 20. "   pub_light_sleep_cnt[4]       , " "0    ,1    "
      BITFLD.LONG 0x68 21. "   pub_light_sleep_cnt[5]       , " "0    ,1    "
      BITFLD.LONG 0x68 22. "   pub_light_sleep_cnt[6]       , " "0    ,1    "
      BITFLD.LONG 0x68 23. "   pub_light_sleep_cnt[7]       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x68 24. "   pub_light_sleep_cnt[8]       , " "0    ,1    "
      BITFLD.LONG 0x68 25. "   pub_light_sleep_cnt[9]       , " "0    ,1    "
      BITFLD.LONG 0x68 26. "   pub_light_sleep_cnt[10]      , " "0    ,1    "
      BITFLD.LONG 0x68 27. "   pub_light_sleep_cnt[11]      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x68 28. "   pub_light_sleep_cnt[12]      , " "0    ,1    "
      BITFLD.LONG 0x68 29. "   pub_light_sleep_cnt[13]      , " "0    ,1    "
      BITFLD.LONG 0x68 30. "   pub_light_sleep_cnt[14]      , " "0    ,1    "
      BITFLD.LONG 0x68 31. "   pub_light_sleep_cnt[15]      , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_ap_pubcp_deep RO"
;-------------------------------------------------
    VARX 0x6C %l DBUS.read(0x00090114)
    TEXTLINE ""
    LINE.LONG 0x6C "chain_aon_ap_pubcp_deep,chain_aon_ap_pubcp_deep"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x6C 0. "   ap_deep_sleep_cnt[0]       , deep sleep counter" "0    ,1    "
      BITFLD.LONG 0x6C 1. "   ap_deep_sleep_cnt[1]       , " "0    ,1    "
      BITFLD.LONG 0x6C 2. "   ap_deep_sleep_cnt[2]       , " "0    ,1    "
      BITFLD.LONG 0x6C 3. "   ap_deep_sleep_cnt[3]       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x6C 4. "   ap_deep_sleep_cnt[4]       , " "0    ,1    "
      BITFLD.LONG 0x6C 5. "   ap_deep_sleep_cnt[5]       , " "0    ,1    "
      BITFLD.LONG 0x6C 6. "   ap_deep_sleep_cnt[6]       , " "0    ,1    "
      BITFLD.LONG 0x6C 7. "   ap_deep_sleep_cnt[7]       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x6C 8. "   pubcp_deep_sleep_cnt[0]    , deep sleep counter" "0    ,1    "
      BITFLD.LONG 0x6C 9. "   pubcp_deep_sleep_cnt[1]    , " "0    ,1    "
      BITFLD.LONG 0x6C 10. "   pubcp_deep_sleep_cnt[2]    , " "0    ,1    "
      BITFLD.LONG 0x6C 11. "   pubcp_deep_sleep_cnt[3]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x6C 12. "   pubcp_deep_sleep_cnt[4]    , " "0    ,1    "
      BITFLD.LONG 0x6C 13. "   pubcp_deep_sleep_cnt[5]    , " "0    ,1    "
      BITFLD.LONG 0x6C 14. "   pubcp_deep_sleep_cnt[6]    , " "0    ,1    "
      BITFLD.LONG 0x6C 15. "   pubcp_deep_sleep_cnt[7]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x6C 16. "   wtlcp_deep_sleep_cnt[0]    , " "0    ,1    "
      BITFLD.LONG 0x6C 17. "   wtlcp_deep_sleep_cnt[1]    , " "0    ,1    "
      BITFLD.LONG 0x6C 18. "   wtlcp_deep_sleep_cnt[2]    , " "0    ,1    "
      BITFLD.LONG 0x6C 19. "   wtlcp_deep_sleep_cnt[3]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x6C 20. "   wtlcp_deep_sleep_cnt[4]    , " "0    ,1    "
      BITFLD.LONG 0x6C 21. "   wtlcp_deep_sleep_cnt[5]    , " "0    ,1    "
      BITFLD.LONG 0x6C 22. "   wtlcp_deep_sleep_cnt[6]    , " "0    ,1    "
      BITFLD.LONG 0x6C 23. "   wtlcp_deep_sleep_cnt[7]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x6C 24. "   pub_deep_sleep_cnt[0]      , deep sleep counter" "0    ,1    "
      BITFLD.LONG 0x6C 25. "   pub_deep_sleep_cnt[1]      , " "0    ,1    "
      BITFLD.LONG 0x6C 26. "   pub_deep_sleep_cnt[2]      , " "0    ,1    "
      BITFLD.LONG 0x6C 27. "   pub_deep_sleep_cnt[3]      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x6C 28. "   pub_deep_sleep_cnt[4]      , " "0    ,1    "
      BITFLD.LONG 0x6C 29. "   pub_deep_sleep_cnt[5]      , " "0    ,1    "
      BITFLD.LONG 0x6C 30. "   pub_deep_sleep_cnt[6]      , " "0    ,1    "
      BITFLD.LONG 0x6C 31. "   pub_deep_sleep_cnt[7]      , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_arm7_deep RO"
;-------------------------------------------------
    VARX 0x70 %l DBUS.read(0x00090115)
    TEXTLINE ""
    LINE.LONG 0x70 "chain_aon_arm7_deep,chain_aon_arm7_deep"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x70 0. "   arm7_deep_sleep_cnt[0]     , deep sleep counter" "0    ,1    "
      BITFLD.LONG 0x70 1. "   arm7_deep_sleep_cnt[1]     , " "0    ,1    "
      BITFLD.LONG 0x70 2. "   arm7_deep_sleep_cnt[2]     , " "0    ,1    "
      BITFLD.LONG 0x70 3. "   arm7_deep_sleep_cnt[3]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x70 4. "   arm7_deep_sleep_cnt[4]     , " "0    ,1    "
      BITFLD.LONG 0x70 5. "   arm7_deep_sleep_cnt[5]     , " "0    ,1    "
      BITFLD.LONG 0x70 6. "   arm7_deep_sleep_cnt[6]     , " "0    ,1    "
      BITFLD.LONG 0x70 7. "   arm7_deep_sleep_cnt[7]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x70 8. "   int_req_pwr_up[0]          , " "0    ,1    "
      BITFLD.LONG 0x70 9. "   int_req_pwr_up[1]          , " "0    ,1    "
      BITFLD.LONG 0x70 10. "   int_req_pwr_up[2]          , " "0    ,1    "
      BITFLD.LONG 0x70 11. "   int_req_pwr_up[3]          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x70 12. "   int_req_pwr_up[4]          , " "0    ,1    "
      BITFLD.LONG 0x70 13. "   int_req_pwr_up[5]          , " "0    ,1    "
      BITFLD.LONG 0x70 14. "   int_req_pwr_up[0]          , " "0    ,1    "
      BITFLD.LONG 0x70 15. "   int_req_pwr_up[1]          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x70 16. "   int_req_pwr_up[2]          , " "0    ,1    "
      BITFLD.LONG 0x70 17. "   int_req_pwr_up[3]          , " "0    ,1    "
      BITFLD.LONG 0x70 18. "   int_req_pwr_up[4]          , " "0    ,1    "
      BITFLD.LONG 0x70 19. "   int_req_pwr_up[5]          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x70 20. "   cgm_pmu_sel[0]             , pmu clk source selection (auto protect)" "0    ,1    "
      BITFLD.LONG 0x70 21. "   cgm_pmu_sel[1]             , pmu clk source selection" "0    ,1    "
      BITFLD.LONG 0x70 22. "   cgm_pmu_sel_reg[0]         , pmu clk source selection (apb reg)" "0    ,1    "
      BITFLD.LONG 0x70 23. "   cgm_pmu_sel_reg[1]         , pmu clk source selection" "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x70 24. "   aon_apb_auto_sel_rc0[0]    , " "0    ,1    "
      BITFLD.LONG 0x70 25. "   aon_apb_auto_sel_rc0[1]    , " "0    ,1    "
      BITFLD.LONG 0x70 26. "   aon_apb_auto_sel_rc0_en    , " "0    ,1    "
      BITFLD.LONG 0x70 27. "   aon_apb_auto_sel_xtl_en    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x70 28. "   cgm_pmu_26m_en             , " "0    ,1    "
      BITFLD.LONG 0x70 29. "   cgm_pmu_26m_sel            , " "0    ,1    "
      BITFLD.LONG 0x70 30. "   sel_32k_reg                , " "0    ,1    "
      BITFLD.LONG 0x70 31. "   reserved                   , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_ap_pubcp_doze RO"
;-------------------------------------------------
    VARX 0x74 %l DBUS.read(0x00090116)
    TEXTLINE ""
    LINE.LONG 0x74 "chain_aon_ap_pubcp_doze,chain_aon_ap_pubcp_doze"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x74 0. "   ap_doze_sleep_cnt[0]        , " "0    ,1    "
      BITFLD.LONG 0x74 1. "   ap_doze_sleep_cnt[1]        , " "0    ,1    "
      BITFLD.LONG 0x74 2. "   ap_doze_sleep_cnt[2]        , " "0    ,1    "
      BITFLD.LONG 0x74 3. "   ap_doze_sleep_cnt[3]        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x74 4. "   ap_doze_sleep_cnt[4]        , " "0    ,1    "
      BITFLD.LONG 0x74 5. "   ap_doze_sleep_cnt[5]        , " "0    ,1    "
      BITFLD.LONG 0x74 6. "   ap_doze_sleep_cnt[6]        , " "0    ,1    "
      BITFLD.LONG 0x74 7. "   ap_doze_sleep_cnt[7]        , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x74 8. "   ap_doze_sleep_cnt[8]        , " "0    ,1    "
      BITFLD.LONG 0x74 9. "   ap_doze_sleep_cnt[9]        , " "0    ,1    "
      BITFLD.LONG 0x74 10. "   ap_doze_sleep_cnt[10]       , " "0    ,1    "
      BITFLD.LONG 0x74 11. "   ap_doze_sleep_cnt[11]       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x74 12. "   ap_doze_sleep_cnt[12]       , " "0    ,1    "
      BITFLD.LONG 0x74 13. "   ap_doze_sleep_cnt[13]       , " "0    ,1    "
      BITFLD.LONG 0x74 14. "   ap_doze_sleep_cnt[14]       , " "0    ,1    "
      BITFLD.LONG 0x74 15. "   ap_doze_sleep_cnt[15]       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x74 16. "   pubcp_doze_sleep_cnt[0]     , " "0    ,1    "
      BITFLD.LONG 0x74 17. "   pubcp_doze_sleep_cnt[1]     , " "0    ,1    "
      BITFLD.LONG 0x74 18. "   pubcp_doze_sleep_cnt[2]     , " "0    ,1    "
      BITFLD.LONG 0x74 19. "   pubcp_doze_sleep_cnt[3]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x74 20. "   pubcp_doze_sleep_cnt[4]     , " "0    ,1    "
      BITFLD.LONG 0x74 21. "   pubcp_doze_sleep_cnt[5]     , " "0    ,1    "
      BITFLD.LONG 0x74 22. "   pubcp_doze_sleep_cnt[6]     , " "0    ,1    "
      BITFLD.LONG 0x74 23. "   pubcp_doze_sleep_cnt[7]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x74 24. "   pubcp_doze_sleep_cnt[8]     , " "0    ,1    "
      BITFLD.LONG 0x74 25. "   pubcp_doze_sleep_cnt[9]     , " "0    ,1    "
      BITFLD.LONG 0x74 26. "   pubcp_doze_sleep_cnt[10]    , " "0    ,1    "
      BITFLD.LONG 0x74 27. "   pubcp_doze_sleep_cnt[11]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x74 28. "   pubcp_doze_sleep_cnt[12]    , " "0    ,1    "
      BITFLD.LONG 0x74 29. "   pubcp_doze_sleep_cnt[13]    , " "0    ,1    "
      BITFLD.LONG 0x74 30. "   pubcp_doze_sleep_cnt[14]    , " "0    ,1    "
      BITFLD.LONG 0x74 31. "   pubcp_doze_sleep_cnt[15]    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_pub_wtlcp_doze RO"
;-------------------------------------------------
    VARX 0x78 %l DBUS.read(0x00090117)
    TEXTLINE ""
    LINE.LONG 0x78 "chain_aon_pub_wtlcp_doze,chain_aon_pub_wtlcp_doze"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x78 0. "   wtlcp_doze_sleep_cnt[0]      , " "0    ,1    "
      BITFLD.LONG 0x78 1. "   wtlcp_doze_sleep_cnt[1]      , " "0    ,1    "
      BITFLD.LONG 0x78 2. "   wtlcp_doze_sleep_cnt[2]      , " "0    ,1    "
      BITFLD.LONG 0x78 3. "   wtlcp_doze_sleep_cnt[3]      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x78 4. "   wtlcp_doze_sleep_cnt[4]      , " "0    ,1    "
      BITFLD.LONG 0x78 5. "   wtlcp_doze_sleep_cnt[5]      , " "0    ,1    "
      BITFLD.LONG 0x78 6. "   wtlcp_doze_sleep_cnt[6]      , " "0    ,1    "
      BITFLD.LONG 0x78 7. "   wtlcp_doze_sleep_cnt[7]      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x78 8. "   wtlcp_doze_sleep_cnt[8]      , " "0    ,1    "
      BITFLD.LONG 0x78 9. "   wtlcp_doze_sleep_cnt[9]      , " "0    ,1    "
      BITFLD.LONG 0x78 10. "   wtlcp_doze_sleep_cnt[10]     , " "0    ,1    "
      BITFLD.LONG 0x78 11. "   wtlcp_doze_sleep_cnt[11]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x78 12. "   wtlcp_doze_sleep_cnt[12]     , " "0    ,1    "
      BITFLD.LONG 0x78 13. "   wtlcp_doze_sleep_cnt[13]     , " "0    ,1    "
      BITFLD.LONG 0x78 14. "   wtlcp_doze_sleep_cnt[14]     , " "0    ,1    "
      BITFLD.LONG 0x78 15. "   wtlcp_doze_sleep_cnt[15]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x78 16. "   ap_pub_deep_sleep_cnt[0]     , " "0    ,1    "
      BITFLD.LONG 0x78 17. "   ap_pub_deep_sleep_cnt[1]     , " "0    ,1    "
      BITFLD.LONG 0x78 18. "   ap_pub_deep_sleep_cnt[2]     , " "0    ,1    "
      BITFLD.LONG 0x78 19. "   ap_pub_deep_sleep_cnt[3]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x78 20. "   ap_pub_deep_sleep_cnt[4]     , " "0    ,1    "
      BITFLD.LONG 0x78 21. "   ap_pub_deep_sleep_cnt[5]     , " "0    ,1    "
      BITFLD.LONG 0x78 22. "   ap_pub_deep_sleep_cnt[6]     , " "0    ,1    "
      BITFLD.LONG 0x78 23. "   ap_pub_deep_sleep_cnt[7]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x78 24. "   ap_pub_deep_sleep_cnt[8]     , " "0    ,1    "
      BITFLD.LONG 0x78 25. "   ap_pub_deep_sleep_cnt[9]     , " "0    ,1    "
      BITFLD.LONG 0x78 26. "   ap_pub_deep_sleep_cnt[10]    , " "0    ,1    "
      BITFLD.LONG 0x78 27. "   ap_pub_deep_sleep_cnt[11]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x78 28. "   ap_pub_deep_sleep_cnt[12]    , " "0    ,1    "
      BITFLD.LONG 0x78 29. "   ap_pub_deep_sleep_cnt[13]    , " "0    ,1    "
      BITFLD.LONG 0x78 30. "   ap_pub_deep_sleep_cnt[14]    , " "0    ,1    "
      BITFLD.LONG 0x78 31. "   ap_pub_deep_sleep_cnt[15]    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_pubcp_wtlcp_sl_cnt RO"
;-------------------------------------------------
    VARX 0x7C %l DBUS.read(0x00090118)
    TEXTLINE ""
    LINE.LONG 0x7C "chain_aon_pubcp_wtlcp_sl_cnt,chain_aon_pubcp_wtlcp_sl_cnt"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x7C 0. "   pubcp_pub_deep_sleep_cnt[0]     , " "0    ,1    "
      BITFLD.LONG 0x7C 1. "   pubcp_pub_deep_sleep_cnt[1]     , " "0    ,1    "
      BITFLD.LONG 0x7C 2. "   pubcp_pub_deep_sleep_cnt[2]     , " "0    ,1    "
      BITFLD.LONG 0x7C 3. "   pubcp_pub_deep_sleep_cnt[3]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x7C 4. "   pubcp_pub_deep_sleep_cnt[4]     , " "0    ,1    "
      BITFLD.LONG 0x7C 5. "   pubcp_pub_deep_sleep_cnt[5]     , " "0    ,1    "
      BITFLD.LONG 0x7C 6. "   pubcp_pub_deep_sleep_cnt[6]     , " "0    ,1    "
      BITFLD.LONG 0x7C 7. "   pubcp_pub_deep_sleep_cnt[7]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x7C 8. "   pubcp_pub_deep_sleep_cnt[8]     , " "0    ,1    "
      BITFLD.LONG 0x7C 9. "   pubcp_pub_deep_sleep_cnt[9]     , " "0    ,1    "
      BITFLD.LONG 0x7C 10. "   pubcp_pub_deep_sleep_cnt[10]    , " "0    ,1    "
      BITFLD.LONG 0x7C 11. "   pubcp_pub_deep_sleep_cnt[11]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x7C 12. "   pubcp_pub_deep_sleep_cnt[12]    , " "0    ,1    "
      BITFLD.LONG 0x7C 13. "   pubcp_pub_deep_sleep_cnt[13]    , " "0    ,1    "
      BITFLD.LONG 0x7C 14. "   pubcp_pub_deep_sleep_cnt[14]    , " "0    ,1    "
      BITFLD.LONG 0x7C 15. "   pubcp_pub_deep_sleep_cnt[15]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x7C 16. "   wtlcp_pub_deep_sleep_cnt[0]     , " "0    ,1    "
      BITFLD.LONG 0x7C 17. "   wtlcp_pub_deep_sleep_cnt[1]     , " "0    ,1    "
      BITFLD.LONG 0x7C 18. "   wtlcp_pub_deep_sleep_cnt[2]     , " "0    ,1    "
      BITFLD.LONG 0x7C 19. "   wtlcp_pub_deep_sleep_cnt[3]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x7C 20. "   wtlcp_pub_deep_sleep_cnt[4]     , " "0    ,1    "
      BITFLD.LONG 0x7C 21. "   wtlcp_pub_deep_sleep_cnt[5]     , " "0    ,1    "
      BITFLD.LONG 0x7C 22. "   wtlcp_pub_deep_sleep_cnt[6]     , " "0    ,1    "
      BITFLD.LONG 0x7C 23. "   wtlcp_pub_deep_sleep_cnt[7]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x7C 24. "   wtlcp_pub_deep_sleep_cnt[8]     , " "0    ,1    "
      BITFLD.LONG 0x7C 25. "   wtlcp_pub_deep_sleep_cnt[9]     , " "0    ,1    "
      BITFLD.LONG 0x7C 26. "   wtlcp_pub_deep_sleep_cnt[10]    , " "0    ,1    "
      BITFLD.LONG 0x7C 27. "   wtlcp_pub_deep_sleep_cnt[11]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x7C 28. "   wtlcp_pub_deep_sleep_cnt[12]    , " "0    ,1    "
      BITFLD.LONG 0x7C 29. "   wtlcp_pub_deep_sleep_cnt[13]    , " "0    ,1    "
      BITFLD.LONG 0x7C 30. "   wtlcp_pub_deep_sleep_cnt[14]    , " "0    ,1    "
      BITFLD.LONG 0x7C 31. "   wtlcp_pub_deep_sleep_cnt[15]    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_wtl2aon_lp_status RO"
;-------------------------------------------------
    VARX 0x80 %l DBUS.read(0x00090119)
    TEXTLINE ""
    LINE.LONG 0x80 "chain_aon_wtl2aon_lp_status,chain_aon_wtl2aon_lp_status"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x80 0. "   wtl2aon_lp_status_h[0]     , " "0    ,1    "
      BITFLD.LONG 0x80 1. "   wtl2aon_lp_status_h[1]     , " "0    ,1    "
      BITFLD.LONG 0x80 2. "   wtl2aon_lp_status_h[2]     , " "0    ,1    "
      BITFLD.LONG 0x80 3. "   wtl2aon_lp_status_h[3]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x80 4. "   wtl2aon_lp_status_h[4]     , " "0    ,1    "
      BITFLD.LONG 0x80 5. "   wtl2aon_lp_status_h[5]     , " "0    ,1    "
      BITFLD.LONG 0x80 6. "   wtl2aon_lp_status_h[6]     , " "0    ,1    "
      BITFLD.LONG 0x80 7. "   wtl2aon_lp_status_h[7]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x80 8. "   wtl2aon_lp_status_h[8]     , " "0    ,1    "
      BITFLD.LONG 0x80 9. "   wtl2aon_lp_status_h[9]     , " "0    ,1    "
      BITFLD.LONG 0x80 10. "   wtl2aon_lp_status_h[10]    , " "0    ,1    "
      BITFLD.LONG 0x80 11. "   wtl2aon_lp_status_h[11]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x80 12. "   wtl2aon_lp_status_h[12]    , " "0    ,1    "
      BITFLD.LONG 0x80 13. "   wtl2aon_lp_status_h[13]    , " "0    ,1    "
      BITFLD.LONG 0x80 14. "   wtl2aon_lp_status_h[14]    , " "0    ,1    "
      BITFLD.LONG 0x80 15. "   wtl2aon_lp_status_h[15]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x80 16. "   wtl2aon_lp_status_h[16]    , " "0    ,1    "
      BITFLD.LONG 0x80 17. "   wtl2aon_lp_status_h[17]    , " "0    ,1    "
      BITFLD.LONG 0x80 18. "   wtl2aon_lp_status_h[18]    , " "0    ,1    "
      BITFLD.LONG 0x80 19. "   wtl2aon_lp_status_h[19]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x80 20. "   wtl2aon_lp_status_h[20]    , " "0    ,1    "
      BITFLD.LONG 0x80 21. "   wtl2aon_lp_status_h[21]    , " "0    ,1    "
      BITFLD.LONG 0x80 22. "   wtl2aon_lp_status_h[22]    , " "0    ,1    "
      BITFLD.LONG 0x80 23. "   wtl2aon_lp_status_h[23]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x80 24. "   wtl2aon_lp_status_h[24]    , " "0    ,1    "
      BITFLD.LONG 0x80 25. "   wtl2aon_lp_status_h[25]    , " "0    ,1    "
      BITFLD.LONG 0x80 26. "   wtl2aon_lp_status_h[26]    , " "0    ,1    "
      BITFLD.LONG 0x80 27. "   wtl2aon_lp_status_h[27]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x80 28. "   wtl2aon_lp_status_h[28]    , " "0    ,1    "
      BITFLD.LONG 0x80 29. "   wtl2aon_lp_status_h[29]    , " "0    ,1    "
      BITFLD.LONG 0x80 30. "   wtl2aon_lp_status_h[30]    , " "0    ,1    "
      BITFLD.LONG 0x80 31. "   wtl2aon_lp_status_h[31]    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_wtl2aon_lp_status1 RO"
;-------------------------------------------------
    VARX 0x84 %l DBUS.read(0x0009011A)
    TEXTLINE ""
    LINE.LONG 0x84 "chain_aon_wtl2aon_lp_status1,chain_aon_wtl2aon_lp_status1"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x84 0. "   wtl2aon_lp_status_l[0]     , " "0    ,1    "
      BITFLD.LONG 0x84 1. "   wtl2aon_lp_status_l[1]     , " "0    ,1    "
      BITFLD.LONG 0x84 2. "   wtl2aon_lp_status_l[2]     , " "0    ,1    "
      BITFLD.LONG 0x84 3. "   wtl2aon_lp_status_l[3]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x84 4. "   wtl2aon_lp_status_l[4]     , " "0    ,1    "
      BITFLD.LONG 0x84 5. "   wtl2aon_lp_status_l[5]     , " "0    ,1    "
      BITFLD.LONG 0x84 6. "   wtl2aon_lp_status_l[6]     , " "0    ,1    "
      BITFLD.LONG 0x84 7. "   wtl2aon_lp_status_l[7]     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x84 8. "   wtl2aon_lp_status_l[8]     , " "0    ,1    "
      BITFLD.LONG 0x84 9. "   wtl2aon_lp_status_l[9]     , " "0    ,1    "
      BITFLD.LONG 0x84 10. "   wtl2aon_lp_status_l[10]    , " "0    ,1    "
      BITFLD.LONG 0x84 11. "   wtl2aon_lp_status_l[11]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x84 12. "   wtl2aon_lp_status_l[12]    , " "0    ,1    "
      BITFLD.LONG 0x84 13. "   wtl2aon_lp_status_l[13]    , " "0    ,1    "
      BITFLD.LONG 0x84 14. "   wtl2aon_lp_status_l[14]    , " "0    ,1    "
      BITFLD.LONG 0x84 15. "   wtl2aon_lp_status_l[15]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x84 16. "   wtl2aon_lp_status_l[16]    , " "0    ,1    "
      BITFLD.LONG 0x84 17. "   wtl2aon_lp_status_l[17]    , " "0    ,1    "
      BITFLD.LONG 0x84 18. "   wtl2aon_lp_status_l[18]    , " "0    ,1    "
      BITFLD.LONG 0x84 19. "   wtl2aon_lp_status_l[19]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x84 20. "   wtl2aon_lp_status_l[20]    , " "0    ,1    "
      BITFLD.LONG 0x84 21. "   wtl2aon_lp_status_l[21]    , " "0    ,1    "
      BITFLD.LONG 0x84 22. "   wtl2aon_lp_status_l[22]    , " "0    ,1    "
      BITFLD.LONG 0x84 23. "   wtl2aon_lp_status_l[23]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x84 24. "   wtl2aon_lp_status_l[24]    , " "0    ,1    "
      BITFLD.LONG 0x84 25. "   wtl2aon_lp_status_l[25]    , " "0    ,1    "
      BITFLD.LONG 0x84 26. "   wtl2aon_lp_status_l[26]    , " "0    ,1    "
      BITFLD.LONG 0x84 27. "   wtl2aon_lp_status_l[27]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x84 28. "   wtl2aon_lp_status_l[28]    , " "0    ,1    "
      BITFLD.LONG 0x84 29. "   wtl2aon_lp_status_l[29]    , " "0    ,1    "
      BITFLD.LONG 0x84 30. "   wtl2aon_lp_status_l[30]    , " "0    ,1    "
      BITFLD.LONG 0x84 31. "   wtl2aon_lp_status_l[31]    , " "0    ,1    "
    TEXTLINE ""
    SGROUP "AON @ chain_aon_pd_wtl_ca53_iso RO"
;-------------------------------------------------
    VARX 0x88 %l DBUS.read(0x0009011B)
    TEXTLINE ""
    LINE.LONG 0x88 "chain_aon_pd_wtl_ca53_iso,chain_aon_pd_wtl_ca53_iso"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x88 10. "   pd_wtlcp_td_iso         , " "0    ,1    "
      BITFLD.LONG 0x88 11. "   pd_wtlcp_lte_p4_iso    , " "0    ,1    "
      BITFLD.LONG 0x88 12. "   pd_wtlcp_lte_p3_iso    , " "0    ,1    "
      BITFLD.LONG 0x88 13. "   pd_wtlcp_lte_p2_iso     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x88 14. "   pd_wtlcp_lte_p1_iso     , " "0    ,1    "
      BITFLD.LONG 0x88 15. "   pd_wtlcp_tgdsp_iso     , " "0    ,1    "
      BITFLD.LONG 0x88 16. "   pd_wtlcp_ldsp_iso      , " "0    ,1    "
      BITFLD.LONG 0x88 17. "   pd_wtlcp_hu3ge_b_iso    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x88 18. "   pd_wtlcp_hu3ge_a_iso    , " "0    ,1    "
      BITFLD.LONG 0x88 19. "   pd_wtlcp_sys_iso       , " "0    ,1    "
      BITFLD.LONG 0x88 20. "   pd_pubcp_sys_iso       , " "0    ,1    "
      BITFLD.LONG 0x88 21. "   pd_pub_sys_iso          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x88 22. "   pd_gpu_top_iso          , " "0    ,1    "
      BITFLD.LONG 0x88 23. "   pd_mm_top_iso          , " "0    ,1    "
      BITFLD.LONG 0x88 24. "   pd_ca53_big_c1_iso     , " "0    ,1    "
      BITFLD.LONG 0x88 25. "   pd_ca53_big_c0_iso      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x88 26. "   pd_ca53_lit_c1_iso      , " "0    ,1    "
      BITFLD.LONG 0x88 27. "   pd_ca53_lit_c0_iso     , " "0    ,1    "
      BITFLD.LONG 0x88 28. "   pd_ca53_big_mp2_iso    , " "0    ,1    "
      BITFLD.LONG 0x88 29. "   pd_ca53_lit_mp2_iso     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x88 30. "   pd_ca53_top_iso         , " "0    ,1    "
      BITFLD.LONG 0x88 31. "   pd_ap_sys_iso          , " "0    ,1    "
    SGROUP "AON @ chain_aon_pd_wtl_ca53_cgm RO"
;-------------------------------------------------
    VARX 0x8C %l DBUS.read(0x0009011C)
    TEXTLINE ""
    LINE.LONG 0x8C "chain_aon_pd_wtl_ca53_cgm,chain_aon_pd_wtl_ca53_cgm"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x8C 10. "   pd_wtlcp_td_cgm_en         , " "0    ,1    "
      BITFLD.LONG 0x8C 11. "   pd_wtlcp_lte_p4_cgm_en    , " "0    ,1    "
      BITFLD.LONG 0x8C 12. "   pd_wtlcp_lte_p3_cgm_en    , " "0    ,1    "
      BITFLD.LONG 0x8C 13. "   pd_wtlcp_lte_p2_cgm_en     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x8C 14. "   pd_wtlcp_lte_p1_cgm_en     , " "0    ,1    "
      BITFLD.LONG 0x8C 15. "   pd_wtlcp_tgdsp_cgm_en     , " "0    ,1    "
      BITFLD.LONG 0x8C 16. "   pd_wtlcp_ldsp_cgm_en      , " "0    ,1    "
      BITFLD.LONG 0x8C 17. "   pd_wtlcp_hu3ge_b_cgm_en    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x8C 18. "   pd_wtlcp_hu3ge_a_cgm_en    , " "0    ,1    "
      BITFLD.LONG 0x8C 19. "   pd_wtlcp_sys_cgm_en       , " "0    ,1    "
      BITFLD.LONG 0x8C 20. "   pd_pubcp_sys_cgm_en       , " "0    ,1    "
      BITFLD.LONG 0x8C 21. "   pd_pub_sys_cgm_en          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x8C 22. "   pd_gpu_top_cgm_en          , " "0    ,1    "
      BITFLD.LONG 0x8C 23. "   pd_mm_top_cgm_en          , " "0    ,1    "
      BITFLD.LONG 0x8C 24. "   pd_ca53_big_c1_cgm_en     , " "0    ,1    "
      BITFLD.LONG 0x8C 25. "   pd_ca53_big_c0_cgm_en      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x8C 26. "   pd_ca53_lit_c1_cgm_en      , " "0    ,1    "
      BITFLD.LONG 0x8C 27. "   pd_ca53_lit_c0_cgm_en     , " "0    ,1    "
      BITFLD.LONG 0x8C 28. "   pd_ca53_big_mp2_cgm_en    , " "0    ,1    "
      BITFLD.LONG 0x8C 29. "   pd_ca53_lit_mp2_cgm_en     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x8C 30. "   pd_ca53_top_cgm_en         , " "0    ,1    "
      BITFLD.LONG 0x8C 31. "   pd_ap_sys_cgm_en          , " "0    ,1    "
    SGROUP "AON @ chain_aon_wtl_ca53_shutdown RO"
;-------------------------------------------------
    VARX 0x90 %l DBUS.read(0x0009011D)
    TEXTLINE ""
    LINE.LONG 0x90 "chain_aon_wtl_ca53_shutdown,chain_aon_wtl_ca53_shutdown"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x90 9. "   pd_wtlcp_td_shutdown_d_b         , " "0    ,1    "
      BITFLD.LONG 0x90 10. "   pd_wtlcp_lte_p4_shutdown_d_b    , " "0    ,1    "
      BITFLD.LONG 0x90 11. "   pd_wtlcp_lte_p3_shutdown_d_b    , " "0    ,1    "
      BITFLD.LONG 0x90 12. "   pd_wtlcp_lte_p2_shutdown_d_b     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x90 13. "   pd_wtlcp_lte_p1_shutdown_d_b     , " "0    ,1    "
      BITFLD.LONG 0x90 14. "   pd_wtlcp_tgdsp_shutdown_d_b     , " "0    ,1    "
      BITFLD.LONG 0x90 15. "   pd_wtlcp_ldsp_shutdown_d_b      , " "0    ,1    "
      BITFLD.LONG 0x90 16. "   pd_wtlcp_hu3ge_b_shutdown_d_b    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x90 17. "   pd_wtlcp_hu3ge_a_shutdown_d_b    , " "0    ,1    "
      BITFLD.LONG 0x90 18. "   pd_wtlcp_sys_shutdown_d_b       , " "0    ,1    "
      BITFLD.LONG 0x90 19. "   pd_pubcp_sys_shutdown_d_b       , " "0    ,1    "
      BITFLD.LONG 0x90 20. "   pd_pub_sys_shutdown_d_b          , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x90 21. "   pd_gpu_top_shutdown_d_b          , " "0    ,1    "
      BITFLD.LONG 0x90 22. "   pd_mm_top_shutdown_d_b          , " "0    ,1    "
      BITFLD.LONG 0x90 23. "   pd_ca53_big_c1_shutdown_d_b     , " "0    ,1    "
      BITFLD.LONG 0x90 24. "   pd_ca53_big_c0_shutdown_d_b      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x90 25. "   pd_ca53_lit_c1_shutdown_d_b      , " "0    ,1    "
      BITFLD.LONG 0x90 26. "   pd_ca53_lit_c0_shutdown_d_b     , " "0    ,1    "
      BITFLD.LONG 0x90 27. "   pd_ca53_big_mp2_shutdown_d_b    , " "0    ,1    "
      BITFLD.LONG 0x90 28. "   pd_ca53_lit_mp2_shutdown_d_b     , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x90 29. "   pd_ca53_top_shutdown_d_b         , " "0    ,1    "
      BITFLD.LONG 0x90 30. "   pd_ca53_top_shutdown_dcdc       , " "0    ,1    "
      BITFLD.LONG 0x90 31. "   pd_ap_sys_shutdown_d_b          , " "0    ,1    "
    SGROUP "AON @ chain_aon_arm7_mem RO"
;-------------------------------------------------
    VARX 0x94 %l DBUS.read(0x0009011E)
    TEXTLINE ""
    LINE.LONG 0x94 "chain_aon_arm7_mem,chain_aon_arm7_mem"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x94 0. "   arm7_deep_sleep_nat    , " "0    ,1    "
      BITFLD.LONG 0x94 1. "   arm7_force_deep_sleep    , " "0    ,1    "
      BITFLD.LONG 0x94 2. "   arm7_deep_sleep        , " "0    ,1    "
      BITFLD.LONG 0x94 3. "   arm7_light_sleep       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x94 4. "   arm7_pwr_pd            , " "0    ,1    "
      BITFLD.LONG 0x94 5. "   arm7_pll_pd              , " "0    ,1    "
      BITFLD.LONG 0x94 6. "   arm7_xtlbuf_pd         , " "0    ,1    "
      BITFLD.LONG 0x94 7. "   arm7_xtl_pd            , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x94 8. "   arm7_mem_sd_imc[0]     , " "0    ,1    "
      BITFLD.LONG 0x94 9. "   arm7_mem_sd_imc[1]       , " "0    ,1    "
      BITFLD.LONG 0x94 10. "   arm7_mem_sd_imc[2]     , " "0    ,1    "
      BITFLD.LONG 0x94 11. "   arm7_mem_sd_uart       , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x94 12. "   arm7_mem_slp_imc[0]    , " "0    ,1    "
      BITFLD.LONG 0x94 13. "   arm7_mem_slp_imc[1]      , " "0    ,1    "
      BITFLD.LONG 0x94 14. "   arm7_mem_slp_imc[2]    , " "0    ,1    "
      BITFLD.LONG 0x94 15. "   arm7_mem_slp_uart      , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x94 16. "   arm7_sram_pd           , " "0    ,1    "
      BITFLD.LONG 0x94 17. "   arm7_sram_pd_dly[0]      , " "0    ,1    "
      BITFLD.LONG 0x94 18. "   arm7_sram_pd_dly[1]    , " "0    ,1    "
      BITFLD.LONG 0x94 19. "   arm7_sram_pd_dly[2]    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x94 20. "   arm7_sram_pd_dly[3]    , " "0    ,1    "
      BITFLD.LONG 0x94 21. "   arm7_sram_pd_dly[4]      , " "0    ,1    "
      BITFLD.LONG 0x94 22. "   arm7_sram_pd_dly[5]    , " "0    ,1    "
TREE.END
;###################Tree###################
TREE "ANA"
    SGROUP "ANA @ chain_ana_pll RO"
;-------------------------------------------------
    VARX 0x04 %l DBUS.read(0x000A0000)
    TEXTLINE ""
    LINE.LONG 0x04 "chain_ana_pll,chain_ana_pll"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x04 0. "   RTC4M0_EN     , " "0    ,1    "
      BITFLD.LONG 0x04 1. "   RTC4M0_RSTB           , " "0    ,1    "
      BITFLD.LONG 0x04 2. "   S_AAPC_PD             , " "0    ,1    "
      BITFLD.LONG 0x04 3. "   M_AAPC_PD            , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 4. "   CPPLL_RST     , " "0    ,1    "
      BITFLD.LONG 0x04 5. "   CPPLL_PD              , " "0    ,1    "
      BITFLD.LONG 0x04 6. "   GPLL_RST              , " "0    ,1    "
      BITFLD.LONG 0x04 7. "   GPLL_PD              , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 8. "   LPLL_RST      , " "0    ,1    "
      BITFLD.LONG 0x04 9. "   LPLL_PD               , " "0    ,1    "
      BITFLD.LONG 0x04 10. "   TWPLL_RST             , " "0    ,1    "
      BITFLD.LONG 0x04 11. "   TWPLL_PD             , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 12. "   RPLL_RST      , " "0    ,1    "
      BITFLD.LONG 0x04 13. "   RPLL_PD               , " "0    ,1    "
      BITFLD.LONG 0x04 14. "   BB_BG_PD              , " "0    ,1    "
      BITFLD.LONG 0x04 15. "   SINDRV_ENA_SQUARE    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x04 16. "   SINDRV_ENA    , " "0    ,1    "
      BITFLD.LONG 0x04 17. "   REC_32MHZ_0_BUF_PD    , " "0    ,1    "
      BITFLD.LONG 0x04 18. "   REC_26MHZ_0_BUF_PD    , " "0    ,1    "
    SGROUP "ANA @ chain_ana_mpll RO"
;-------------------------------------------------
    VARX 0x08 %l DBUS.read(0x000A0100)
    TEXTLINE ""
    LINE.LONG 0x08 "chain_ana_mpll,chain_ana_mpll"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x08 0. "   MPLL_THM0_RSTN    , " "0    ,1    "
      BITFLD.LONG 0x08 1. "   MPLL_THM0_PD    , " "0    ,1    "
      BITFLD.LONG 0x08 2. "   BMPLL_RST    , " "0    ,1    "
      BITFLD.LONG 0x08 3. "   BMPLL_PD    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x08 4. "   MPLL_RST          , " "0    ,1    "
      BITFLD.LONG 0x08 5. "   MPLL_PD         , " "0    ,1    "
    SGROUP "ANA @ chain_ana_dpll RO"
;-------------------------------------------------
    VARX 0x0C %l DBUS.read(0x000A0200)
    TEXTLINE ""
    LINE.LONG 0x0C "chain_ana_dpll,chain_ana_dpll"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x0C 0. "   DPLL_THM1_RSTN    , " "0    ,1    "
      BITFLD.LONG 0x0C 1. "   DPLL_THM1_PD    , " "0    ,1    "
      BITFLD.LONG 0x0C 2. "   DPLL_RST    , " "0    ,1    "
      BITFLD.LONG 0x0C 3. "   DPLL_PD    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x0C 4. "   DESPLL_RST        , " "0    ,1    "
      BITFLD.LONG 0x0C 5. "   DESPLL_PD       , " "0    ,1    "
    SGROUP "ANA @ chain_ana_efs RO"
;-------------------------------------------------
    VARX 0x10 %l DBUS.read(0x000A0300)
    TEXTLINE ""
    LINE.LONG 0x10 "chain_ana_efs,chain_ana_efs"
    TEXTLINE ""
    TEXTLINE ""
      BITFLD.LONG 0x10 0. "   EFS2_ENK2    , " "0    ,1    "
      BITFLD.LONG 0x10 1. "   EFS2_ENK1     , " "0    ,1    "
      BITFLD.LONG 0x10 2. "   EFS2_PD       , " "0    ,1    "
      BITFLD.LONG 0x10 3. "   EFS1_ENK2    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 4. "   EFS1_ENK1    , " "0    ,1    "
      BITFLD.LONG 0x10 5. "   EFS1_PD       , " "0    ,1    "
      BITFLD.LONG 0x10 6. "   EFS0_ENK2     , " "0    ,1    "
      BITFLD.LONG 0x10 7. "   EFS0_ENK1    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 8. "   EFS0_PD      , " "0    ,1    "
      BITFLD.LONG 0x10 9. "   PORTRESET0    , " "0    ,1    "
      BITFLD.LONG 0x10 10. "   PORTRESET0    , " "0    ,1    "
      BITFLD.LONG 0x10 11. "   THM2_RSTB    , " "0    ,1    "
    TEXTLINE ""
      BITFLD.LONG 0x10 12. "   THM2_PD      , " "0    ,1    "
TREE.END
