;This file is generated by Trace32PerBuilder Version:1.0.
config 16. 8.
width 61.
BASE EAPB:0x0
;###################Tree###################
TREE "PUB"
    SGROUP "u_pub_top @ djtag_out_0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 4(0x4) mod 0(0x0) sig 0(0x0)" 
    VARX 0x00 %l SWD.read(0x00000008)
    TEXTLINE ""
    LINE.LONG 0x00 " djtag_out_0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "              dmc_stop ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "          dmc_stop_ch6 ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "          dmc_stop_ch5 ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "          dmc_stop_ch4 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "          dmc_stop_ch3 ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "          dmc_stop_ch2 ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "          dmc_stop_ch1 ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "          dmc_stop_ch0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. "             dmc_sleep ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "         dmc_sleep_ch6 ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "         dmc_sleep_ch5 ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "         dmc_sleep_ch4 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. "         dmc_sleep_ch3 ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "         dmc_sleep_ch2 ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "         dmc_sleep_ch1 ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "         dmc_sleep_ch0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. " ddr_self_refresh_flag ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  ddr_self_refresh_req ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "               dfs_req ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "               dfs_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 20. "              dfs_resp ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "             dfs_error ," "0   ,%d..."
    BITFLD.LONG 0x00 22.--24. "           dfs_frq_sel ," "0x0 ,%x..."
    BITFLD.LONG 0x00 25. "        int_dfs_giveup ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "          int_dfs_deny ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "       int_dmc_mpu_vio ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "            int_mem_fw ," "0   ,%d..."
    BITFLD.LONG 0x00 29. " int_hardware_dfs_exit ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 30. "      int_dfs_complete ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "         int_dfs_error ," "0   ,%d..."
    SGROUP "u_pub_top @ djtag_out_1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 1(0x1)" 
    VARX 0x00 %l SWD.read(0x00010000)
    TEXTLINE ""
    LINE.LONG 0x00 " djtag_out_1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "       pub_dmc_dfs_req ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "        pub_dfs_lp_req ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "        pub_sleep_lock ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "          pub_dfs_lock ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "        dmc_ext_clk_en ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " dmc_sref_auto_gate_en ," "0   ,%d..."
    BITFLD.LONG 0x00 6. " r_pll_pd_default_high ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--8. "      dmc_ckg_clk_mode ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 9.--10. "        dmc_ckg_x1_sel ," "0x0 ,%x..."
    BITFLD.LONG 0x00 11.--12. "        dmc_ckg_d2_sel ," "0x0 ,%x..."
    BITFLD.LONG 0x00 13.--15. "           dmc_ckg_sel ," "0x0 ,%x..."
    BITFLD.LONG 0x00 16. "          dfs_fc_ack_o ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 17. "          dfs_fc_req_o ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "          dfs_fc_ack_i ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "          dfs_fc_req_i ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "                  1'b0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 21. "                  1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 22.--23. "          dfs_clk_mode ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24.--25. "      dmc_cur_clk_mode ," "0x0 ,%x..."
    BITFLD.LONG 0x00 26.--29. "  dmc_clk_hw_cur_state ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 30. "     dmc_clk_d2_cgm_en ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "    dmc_clk_dfs_cgm_en ," "0   ,%d..."
    SGROUP "u_pub_top @ djtag_out_2"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 2(0x2)" 
    VARX 0x00 %l SWD.read(0x00020000)
    TEXTLINE ""
    LINE.LONG 0x00 " djtag_out_2 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "                       1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 1. "                       1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 2. "                       1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 3. "      cgm_busy_lpc_pubcp_ag ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "          cgm_busy_lpc_agcp ," "0    ,%d..."
    BITFLD.LONG 0x00 5. "         cgm_busy_lpc_pubcp ," "0    ,%d..."
    BITFLD.LONG 0x00 6. "        cgm_busy_lpc_ap_aon ," "0    ,%d..."
    BITFLD.LONG 0x00 7. "           cgm_busy_lpc_aon ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. "            cgm_busy_lpc_ap ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "       cgm_busy_lpc_dpu_isp ," "0    ,%d..."
    BITFLD.LONG 0x00 10. "       cgm_busy_lpc_isp_raw ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "           cgm_busy_lpc_dpu ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. " cgm_busy_clk_dmc_d2_dfimon ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "    cgm_busy_latmon_clk_dfs ," "0    ,%d..."
    BITFLD.LONG 0x00 14. "   cgm_busy_dfs_deskew_ctrl ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "      cgm_busy_dfs_top_ctrl ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "       cgm_busy_clk_pub_dfs ," "0    ,%d..."
    BITFLD.LONG 0x00 17.--18. "    pubcp_ag_qosc_port_busy ," "0x0  ,%x..."
    BITFLD.LONG 0x00 19.--20. "      ap_aon_qosc_port_busy ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21.--22. "                      2'b00 ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 23.--24. "    dpu_dcam_qosc_port_busy ," "0x0  ,%x..."
    BITFLD.LONG 0x00 25.--31. "             qosc_port_busy ," "0x0  ,%x..."
    SGROUP "u_pub_top.u_pub_wrap.u_async_bridge_top_r_aon.u_async_bridge_top_r @ bridge_debug_sugnal_r_aon"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 3(0x3)" 
    VARX 0x00 %l SWD.read(0x00030000)
    TEXTLINE ""
    LINE.LONG 0x00 " bridge_debug_sugnal_r_aon "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " mask_req_sync ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "      mask_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " idle_req_sync ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "      idle_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "       mask_en ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " fifo_sync_clr ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "  async_config ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. "            cs ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " aw_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "  w_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " ar_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "   b_ch_r_full ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "   r_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "  aw_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "   w_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  ar_ch_r_full ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "  b_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "  r_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "     AWVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "     AWREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "      WVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "      WREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "     ARVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "     ARREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "      BVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      BREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      RVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "      RREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "         2'b00 ," "0x0 ,%x..."
    SGROUP "rsv @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 4(0x4)" 
    VARX 0x00 %l SWD.read(0x00040000)
    TEXTLINE ""
    LINE.LONG 0x00 "  "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 1. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 3. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 6. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. " 0 ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 11. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 13. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 15. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 16. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 17. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 19. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 20. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 21. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 23. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 24. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 25. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 27. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 28. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 29. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. " 0 ," "0x0 ,%x..."
    SGROUP "rsv @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 5(0x5)" 
    VARX 0x00 %l SWD.read(0x00050000)
    TEXTLINE ""
    LINE.LONG 0x00 "  "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 1. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 3. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 6. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. " 0 ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 11. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 13. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 15. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 16. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 17. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 19. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 20. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 21. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 23. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 24. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 25. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 27. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 28. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 29. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. " 0 ," "0x0 ,%x..."
    SGROUP "rsv @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 6(0x6)" 
    VARX 0x00 %l SWD.read(0x00060000)
    TEXTLINE ""
    LINE.LONG 0x00 "  "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 1. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 3. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 6. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. " 0 ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 11. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 13. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 15. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 16. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 17. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 19. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 20. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 21. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 23. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 24. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 25. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 27. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 28. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 29. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. " 0 ," "0x0 ,%x..."
    SGROUP "rsv @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 7(0x7)" 
    VARX 0x00 %l SWD.read(0x00070000)
    TEXTLINE ""
    LINE.LONG 0x00 "  "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 1. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 3. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 6. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. " 0 ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 11. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 13. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 15. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 16. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 17. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 19. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 20. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 21. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 23. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 24. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 25. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 27. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 28. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 29. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. " 0 ," "0x0 ,%x..."
    SGROUP "rsv @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 8(0x8)" 
    VARX 0x00 %l SWD.read(0x00080000)
    TEXTLINE ""
    LINE.LONG 0x00 "  "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 1. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 3. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 6. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. " 0 ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 11. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 13. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 15. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 16. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 17. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 19. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 20. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 21. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 23. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 24. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 25. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 27. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 28. " 0 ," "0   ,%d..."
    BITFLD.LONG 0x00 29. " 0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. " 0 ," "0x0 ,%x..."
    SGROUP "u_pub_top.u_pub_wrap.u_async_bridge_top_r_pubcp.u_async_bridge_top_r @ bridge_debug_signal_r_pubcp"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 9(0x9)" 
    VARX 0x00 %l SWD.read(0x00090000)
    TEXTLINE ""
    LINE.LONG 0x00 " bridge_debug_signal_r_pubcp "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " mask_req_sync ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "      mask_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " idle_req_sync ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "      idle_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "       mask_en ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " fifo_sync_clr ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "  async_config ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. "            cs ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " aw_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "  w_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " ar_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "   b_ch_r_full ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "   r_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "  aw_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "   w_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  ar_ch_r_full ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "  b_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "  r_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "     AWVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "     AWREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "      WVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "      WREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "     ARVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "     ARREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "      BVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      BREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      RVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "      RREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "         2'b00 ," "0x0 ,%x..."
    SGROUP "u_pub_top.u_pub_wrap.u_async_bridge_top_r_wtlcp.async_bridge_top_r @ bridge_debug_signal_r_wtlcp"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 10(0xa)" 
    VARX 0x00 %l SWD.read(0x000A0000)
    TEXTLINE ""
    LINE.LONG 0x00 " bridge_debug_signal_r_wtlcp "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " mask_req_sync ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "      mask_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " idle_req_sync ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "      idle_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "       mask_en ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " fifo_sync_clr ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "  async_config ," "0   ,%d..."
    BITFLD.LONG 0x00 7.--9. "            cs ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " aw_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "  w_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 12. " ar_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "   b_ch_r_full ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "   r_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "  aw_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "   w_ch_r_full ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  ar_ch_r_full ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "  b_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "  r_ch_r_empty ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "     AWVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "     AWREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "      WVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "      WREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "     ARVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "     ARREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "      BVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      BREADY_S ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      RVALID_S ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "      RREADY_S ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 30.--31. "         2'b00 ," "0x0 ,%x..."
    SGROUP "u_pub_top @ bus_ot_detect_cpu_gpu"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 11(0xb)" 
    VARX 0x00 %l SWD.read(0x000B0000)
    TEXTLINE ""
    LINE.LONG 0x00 " bus_ot_detect_cpu_gpu "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--4. "   rd_trans_cnt_gpu ," "0    ,%d..."
    BITFLD.LONG 0x00 5.--9. "   wr_trans_cnt_gpu ," "0    ,%d..."
    BITFLD.LONG 0x00 10.--14. " leading_wr_cnt_gpu ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "     trans_idle_gpu ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--20. "   rd_trans_cnt_cpu ," "0    ,%d..."
    BITFLD.LONG 0x00 21.--25. "   wr_trans_cnt_cpu ," "0    ,%d..."
    BITFLD.LONG 0x00 26.--30. " leading_wr_cnt_cpu ," "0    ,%d..."
    BITFLD.LONG 0x00 31. "     trans_idle_cpu ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "u_pub_top @ bus_ot_detect_isp_wtlcp"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 12(0xc)" 
    VARX 0x00 %l SWD.read(0x000C0000)
    TEXTLINE ""
    LINE.LONG 0x00 " bus_ot_detect_isp_wtlcp "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--4. "   rd_trans_cnt_wtlcp ," "0    ,%d..."
    BITFLD.LONG 0x00 5.--9. "   wr_trans_cnt_wtlcp ," "0    ,%d..."
    BITFLD.LONG 0x00 10.--14. " leading_wr_cnt_wtlcp ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "     trans_idle_wtlcp ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--20. "     rd_trans_cnt_isp ," "0    ,%d..."
    BITFLD.LONG 0x00 21.--25. "     wr_trans_cnt_isp ," "0    ,%d..."
    BITFLD.LONG 0x00 26.--30. "   leading_wr_cnt_isp ," "0    ,%d..."
    BITFLD.LONG 0x00 31. "       trans_idle_isp ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_dpu_isp_merge_mtx_wrap @ nic400_dpu_isp_merge_mtx_dbg_bus"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 13(0xd)" 
    VARX 0x00 %l SWD.read(0x000D0000)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_dpu_isp_merge_mtx_dbg_bus "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--5. "   rd_trans_cnt_m1 ," "0    ,%d..."
    BITFLD.LONG 0x00 6.--11. "   wr_trans_cnt_m1 ," "0    ,%d..."
    BITFLD.LONG 0x00 12.--17. " leading_wr_cnt_m1 ," "0    ,%d..."
    BITFLD.LONG 0x00 18. "     trans_idle_m1 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19.--24. "   rd_trans_cnt_m0 ," "0    ,%d..."
    BITFLD.LONG 0x00 25.--30. "   wr_trans_cnt_m0 ," "0    ,%d..."
    BITFLD.LONG 0x00 31. "              1'b0 ," "0    ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_pubcp_ag_merge_mtx_wrap @ nic400_pubcp_ag_merge_mtx_dbg_bus"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 14(0xe)" 
    VARX 0x00 %l SWD.read(0x000E0000)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_pubcp_ag_merge_mtx_dbg_bus "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--5. "      rd_trans_cnt_m1 ," "0    ,%d..."
    BITFLD.LONG 0x00 6.--11. "      wr_trans_cnt_m1 ," "0    ,%d..."
    BITFLD.LONG 0x00 12.--17. "    leading_wr_cnt_m1 ," "0    ,%d..."
    BITFLD.LONG 0x00 18. "        trans_idle_m1 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19.--25. "      rd_trans_cnt_m0 ," "0    ,%d..."
    BITFLD.LONG 0x00 26.--31. " wr_trans_cnt_m0[5:0] ," "0    ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_ap_aon_merge_mtx_wrap @ nic400_ap_aon_merge_mtx_dbg_bus"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 15(0xf)" 
    VARX 0x00 %l SWD.read(0x000F0000)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_ap_aon_merge_mtx_dbg_bus "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--5. "   rd_trans_cnt_m1 ," "0    ,%d..."
    BITFLD.LONG 0x00 6.--11. "   wr_trans_cnt_m1 ," "0    ,%d..."
    BITFLD.LONG 0x00 12.--17. " leading_wr_cnt_m1 ," "0    ,%d..."
    BITFLD.LONG 0x00 18. "     trans_idle_m1 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19.--24. "   rd_trans_cnt_m0 ," "0    ,%d..."
    BITFLD.LONG 0x00 25.--30. "   wr_trans_cnt_m0 ," "0    ,%d..."
    BITFLD.LONG 0x00 31. "              1'b0 ," "0    ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top @ nic400_pub_cfg_mtx_dbg_bus"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 16(0x10)" 
    VARX 0x00 %l SWD.read(0x00100000)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_pub_cfg_mtx_dbg_bus "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--2. "    rd_trans_cnt_m0 ," "0     ,%d..."
    BITFLD.LONG 0x00 3.--5. "    wr_trans_cnt_m0 ," "0     ,%d..."
    BITFLD.LONG 0x00 6.--8. "  leading_wr_cnt_m0 ," "0     ,%d..."
    BITFLD.LONG 0x00 9. "      trans_idle_m0 ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10.--19. " pub_int_cg_st[9:0] ," "0x0   ,%x..."
    BITFLD.LONG 0x00 20. "   pub_mem_fw_cg_st ," "0     ,%d..."
    BITFLD.LONG 0x00 21. "          rst_phy_n ," "0     ,%d..."
    BITFLD.LONG 0x00 22. "               1'b0 ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 23. "          rst_dmc_n ," "0     ,%d..."
    BITFLD.LONG 0x00 24. "       rst_dmc_sc_n ," "0     ,%d..."
    BITFLD.LONG 0x00 25.--31. "               7'h0 ," "0x0   ,%x..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_pub_wrap.u_nic400_isp_vdsp_merge_mtx_wrap @ nic400_misc_mtx_dbg_bus___pubcp_ag__ap_aon__dpu_isp"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 17(0x11)" 
    VARX 0x00 %l SWD.read(0x00110000)
    TEXTLINE ""
    LINE.LONG 0x00 " nic400_misc_mtx_dbg_bus___pubcp_ag__ap_aon__dpu_isp "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " pubcp_ag__wr_trans_cnt_m0[6] ," "0    ,%d..."
    BITFLD.LONG 0x00 1.--7. "  pubcp_ag__leading_wr_cnt_m0 ," "0    ,%d..."
    BITFLD.LONG 0x00 8. "      pubcp_ag__trans_idle_m0 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 9.--11. "                         3'h0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 12.--17. "    ap_aon__leading_wr_cnt_m0 ," "0    ,%d..."
    BITFLD.LONG 0x00 18. "        ap_aon__trans_idle_m0 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "                         1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 20.--25. "    dpu_isp_leading_wr_cnt_m0 ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "        dpu_isp_trans_idle_m0 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 27.--31. "                         5'h0 ," "0x0  ,%x..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_debug_bus_pubsys.ddrc_phy_dbg_0


(TBD, left untouched) @ ddrc_phy_dbg_0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 18(0x12)" 
    VARX 0x00 %l SWD.read(0x00120000)
    TEXTLINE ""
    LINE.LONG 0x00 " ddrc_phy_dbg_0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "                    dram_dfi_init_complete_cha ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "                       dram_dfi_init_start_cha ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 2. "                 phy_db1_dll_acc_min_pulse_cha ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "                 phy_db1_dll_acc_max_pulse_cha ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "                 phy_db0_dll_acc_min_pulse_cha ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "                 phy_db0_dll_acc_max_pulse_cha ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 6. "                  phy_ac_dll_acc_min_pulse_cha ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "                  phy_ac_dll_acc_max_pulse_cha ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. "                                    sre_io_cha ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "                                   HRESETn_cha ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "                                  HCLK_cha_buf ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "                      CHA_cst_gate_process_out ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. "                       CHA_cst_gate_process_in ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "                              CHA_dll_lock_out ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "                               CHA_dll_lock_in ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "                                      rst_n_mc ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "                                          1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "                                      dcc_rstn ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "                                          1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 19.--21. "                            ctrl_speed_set_sel ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "                                  pll_lock_out ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "                                   pll_lock_in ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 24. "                                  dfs_lock_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "                                  dfs_lock_req ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26.--27. " dpll_pre_div_monitor_gate_auto_en_status[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 28.--29. "      dpll_pre_div_monitor_wait_en_status[1:0] ," "0x0 ,%x..."
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_ch0(



(TBD, left untouched) @ ddrc_phy_dbg_1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 19(0x13)" 
    VARX 0x00 %l SWD.read(0x00130000)
    TEXTLINE ""
    LINE.LONG 0x00 " ddrc_phy_dbg_1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "    dram_dfi_init_complete_chb ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "       dram_dfi_init_start_chb ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " phy_db1_dll_acc_min_pulse_chb ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. " phy_db1_dll_acc_max_pulse_chb ," "0   ,%d..."
    BITFLD.LONG 0x00 4. " phy_db0_dll_acc_min_pulse_chb ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " phy_db0_dll_acc_max_pulse_chb ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 6. "  phy_ac_dll_acc_min_pulse_chb ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "  phy_ac_dll_acc_max_pulse_chb ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "                    sre_io_chb ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 9. "                   HRESETn_chb ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "                  HCLK_chb_buf ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "      CHB_cst_gate_process_out ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. "       CHB_cst_gate_process_in ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "              CHB_dll_lock_out ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "               CHB_dll_lock_in ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "           deskew_dll_lock_1st ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "         deskew_dll_adjs_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "                deskew_dll_err ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "               deskew_dll_lock ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "           deskew_dll_adjs_sat ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "                        pd_iso ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 21. "                        pd_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 22. "                  pll_lock_out ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "                   pll_lock_in ," "0   ,%d..."
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_ch0 @ ddrc_phy_dbg_2"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 20(0x14)" 
    VARX 0x00 %l SWD.read(0x00140000)
    TEXTLINE ""
    LINE.LONG 0x00 " ddrc_phy_dbg_2 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--9. "          dram_dfi_wrdata_p0 ," "0x0   ,%x..."
    BITFLD.LONG 0x00 10. "    dram_dfi_wrdata_en_p1[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 11. "    dram_dfi_wrdata_en_p0[0] ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. " dram_dfi_rddata_valid_w0[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 13. "    dram_dfi_rddata_en_p1[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 14. "    dram_dfi_rddata_en_p0[0] ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "         dram_dfi_cs_n_p1[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 16. "         dram_dfi_cs_n_p0[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 17. "             ctrl_cmd_on_cha ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "              ctrl_wr_on_cha ," "0     ,%d..."
    BITFLD.LONG 0x00 19. "              ctrl_rd_on_cha ," "0     ,%d..."
    BITFLD.LONG 0x00 20. "          jitter_det_region4 ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 21. "          jitter_det_region0 ," "0     ,%d..."
    BITFLD.LONG 0x00 22.--23. "                       2'b00 ," "0x0   ,%x..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_ch0 @ ddrc_phy_dbg_3"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 21(0x15)" 
    VARX 0x00 %l SWD.read(0x00150000)
    TEXTLINE ""
    LINE.LONG 0x00 " ddrc_phy_dbg_3 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--9. "          dram_dfi_rddata_w0 ," "0x0   ,%x..."
    BITFLD.LONG 0x00 10. "    dram_dfi_wrdata_en_p1[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 11. "    dram_dfi_wrdata_en_p0[0] ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. " dram_dfi_rddata_valid_w0[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 13. "    dram_dfi_rddata_en_p1[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 14. "    dram_dfi_rddata_en_p0[0] ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "         dram_dfi_cs_n_p1[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 16. "         dram_dfi_cs_n_p0[0] ," "0     ,%d..."
    BITFLD.LONG 0x00 17. "             ctrl_cmd_on_chb ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "              ctrl_wr_on_chb ," "0     ,%d..."
    BITFLD.LONG 0x00 19. "              ctrl_rd_on_chb ," "0     ,%d..."
    BITFLD.LONG 0x00 20.--23. "                        4'h0 ," "0x0   ,%x..."
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_ch0 @ ddrc_phy_dbg_4"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 22(0x16)" 
    VARX 0x00 %l SWD.read(0x00160000)
    TEXTLINE ""
    LINE.LONG 0x00 " ddrc_phy_dbg_4 ,24'h0"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_ch0 @ ddrc_phy_dbg_5"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 23(0x17)" 
    VARX 0x00 %l SWD.read(0x00170000)
    TEXTLINE ""
    LINE.LONG 0x00 " ddrc_phy_dbg_5 ,24'h0"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_ch0 @ ddrc_phy_dbg_6"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 24(0x18)" 
    VARX 0x00 %l SWD.read(0x00180000)
    TEXTLINE ""
    LINE.LONG 0x00 " ddrc_phy_dbg_6 ,24'h0"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_ch0 @ ddrc_phy_dbg_7"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 25(0x19)" 
    VARX 0x00 %l SWD.read(0x00190000)
    TEXTLINE ""
    LINE.LONG 0x00 " ddrc_phy_dbg_7 ,24'h0"
    TEXTLINE ""
    SGROUP "proj_top_th.chip_top.dut.u_digital_top.u_sys_pub.u_pub_top.u_debug_bus_pubsys @ Reserved"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 26(0x1a)" 
    VARX 0x00 %l SWD.read(0x001A0000)
    TEXTLINE ""
    LINE.LONG 0x00 " Reserved ,32'd0"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top @ qosc_debug_bus0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 27(0x1b)" 
    VARX 0x00 %l SWD.read(0x001B0000)
    TEXTLINE ""
    LINE.LONG 0x00 " qosc_debug_bus0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--6. " axi_port_wr_idle ," "0x0  ,%x..."
    BITFLD.LONG 0x00 7. "             1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--14. " axi_port_rd_idle ," "0x0  ,%x..."
    BITFLD.LONG 0x00 15. "             1'b0 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "   awurgent_selm0 ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "   arurgent_selm0 ," "0    ,%d..."
    BITFLD.LONG 0x00 18. "   awurgent_selm1 ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "   arurgent_selm1 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 20. "   awurgent_selm2 ," "0    ,%d..."
    BITFLD.LONG 0x00 21. "   arurgent_selm2 ," "0    ,%d..."
    BITFLD.LONG 0x00 22. "   awurgent_selm3 ," "0    ,%d..."
    BITFLD.LONG 0x00 23. "   arurgent_selm3 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 24. "   awurgent_selm4 ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "   arurgent_selm4 ," "0    ,%d..."
    BITFLD.LONG 0x00 26. "   awurgent_selm5 ," "0    ,%d..."
    BITFLD.LONG 0x00 27. "   arurgent_selm5 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 28. "   awurgent_selm6 ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "   arurgent_selm6 ," "0    ,%d..."
    BITFLD.LONG 0x00 30.--31. "            2'b00 ," "0x0  ,%x..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top @ qosc_debug_bus1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 28(0x1c)" 
    VARX 0x00 %l SWD.read(0x001C0000)
    TEXTLINE ""
    LINE.LONG 0x00 " qosc_debug_bus1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " dpu_dcam_axi_port_idle[0] ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "          axi_port_idle[5] ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "          axi_port_idle[2] ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "          axi_port_idle[0] ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "        latmon_dfs_req_dpu ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "      latmon_dfs_req_wtlcp ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "        bwmon_f_up_req_isp ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "        bwmon_f_up_req_dpu ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. "       bwmon_f_up_req_dcam ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "  latmon_timer_start_wtlcp ," "0   ,%d..."
    BITFLD.LONG 0x00 10.--11. "                awurgents2 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 12.--13. "                arurgents2 ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14.--15. "                awurgents0 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 16.--17. "                arurgents0 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 18. "            arurgent_selm2 ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "            awurgent_selm0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 20.--21. "     latmon_urgency_wr_dpu ," "0x0 ,%x..."
    BITFLD.LONG 0x00 22.--23. "     latmon_urgency_rd_dpu ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24.--25. "    latmon_urgency_wr_dcam ," "0x0 ,%x..."
    BITFLD.LONG 0x00 26.--27. "    latmon_urgency_rd_dcam ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 28.--29. "   latmon_urgency_wr_wtlcp ," "0x0 ,%x..."
    BITFLD.LONG 0x00 30.--31. "   latmon_urgency_rd_wtlcp ," "0x0 ,%x..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top @ qosc_debug_bus2"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 29(0x1d)" 
    VARX 0x00 %l SWD.read(0x001D0000)
    TEXTLINE ""
    LINE.LONG 0x00 " qosc_debug_bus2 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--6. " latency_actual_wr_wtlcp[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 7. "   latency_actual_wr_wtlcp[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--14. " latency_target_wr_wtlcp[11:5] ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "   latency_target_wr_wtlcp[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--22. " latency_actual_rd_wtlcp[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 23. "   latency_actual_rd_wtlcp[30] ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--30. " latency_target_rd_wtlcp[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 31. "   latency_target_rd_wtlcp[30] ," "0    ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top @ qosc_debug_bus3"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 30(0x1e)" 
    VARX 0x00 %l SWD.read(0x001E0000)
    TEXTLINE ""
    LINE.LONG 0x00 " qosc_debug_bus3 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--6. " latency_actual_wr_dcam[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 7. "   latency_actual_wr_dcam[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--14. " latency_target_wr_dcam[11:5] ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "   latency_target_wr_dcam[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--22. " latency_actual_rd_dcam[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 23. "   latency_actual_rd_dcam[30] ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--30. " latency_target_rd_dcam[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 31. "   latency_target_rd_dcam[30] ," "0    ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_pub_wrap.u_qos_ctrl_top @ qosc_debug_bus4"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 31(0x1f)" 
    VARX 0x00 %l SWD.read(0x001F0000)
    TEXTLINE ""
    LINE.LONG 0x00 " qosc_debug_bus4 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--6. " latency_actual_wr_dpu[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 7. "   latency_actual_wr_dpu[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--14. " latency_target_wr_dpu[11:5] ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 15. "   latency_target_wr_dpu[30] ," "0    ,%d..."
    BITFLD.LONG 0x00 16.--22. " latency_actual_rd_dpu[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 23. "   latency_actual_rd_dpu[30] ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--30. " latency_target_rd_dpu[11:5] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 31. "   latency_target_rd_dpu[30] ," "0    ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top @ pub_dbg_info_add_0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 32(0x20)" 
    VARX 0x00 %l SWD.read(0x00200000)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_info_add_0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--2. "      dfs_sw_fsm_state[2:0] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 3. "       dmc_clk_init_sw_done ," "0    ,%d..."
    BITFLD.LONG 0x00 4. "      dmc_clk_init_sw_start ," "0    ,%d..."
    BITFLD.LONG 0x00 5.--9. "      hw_dfs_fsm_state[4:0] ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "             cgm_pub_dfs_en ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "                       1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "                       1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "         st_dpll0_clkout_en ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "            dpll0_clkout_en ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "      cgm_busy_vote_pub_dfs ," "0    ,%d..."
    BITFLD.LONG 0x00 16. "                       1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "  pub_clk_dfs_deskew_cgm_en ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "    pub_clk_dfs_ctrl_cgm_en ," "0    ,%d..."
    BITFLD.LONG 0x00 19. " pub_clk_dfs_lp_ctrl_cgm_en ," "0    ,%d..."
    BITFLD.LONG 0x00 20. "           pub_dfs_sleep_on ," "0    ,%d..."
    BITFLD.LONG 0x00 21. "       cgm_busy_clk_pub_dfs ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "         ddr_clk_auto_en_or ," "0    ,%d..."
    BITFLD.LONG 0x00 23. "         cgm_busy_ddr_umctl ," "0    ,%d..."
    BITFLD.LONG 0x00 24. "       cgm_busy_all_ddrc_ch ," "0    ,%d..."
    BITFLD.LONG 0x00 25. "       cgm_busy_lpc_pub_cfg ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "         cgm_busy_clk_cssys ," "0    ,%d..."
    BITFLD.LONG 0x00 27. "       cgm_busy_clk_aon_apb ," "0    ,%d..."
    BITFLD.LONG 0x00 28. "       cgm_busy_clk_dmc_ref ," "0    ,%d..."
    BITFLD.LONG 0x00 29. "             cgm_en_clk_dmc ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 30. "       dmc_clk_pd_d2_cgm_en ," "0    ,%d..."
    BITFLD.LONG 0x00 31. "          dmc_clk_x2_cgm_en ," "0    ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.pub_dbg_info_add_1 @ pub_dbg_info_add_1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 33(0x21)" 
    VARX 0x00 %l SWD.read(0x00210000)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_info_add_1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--2. " dmc_phy_speed_set_sel[2:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 3. "           dmc_sleep_finish ," "0   ,%d..."
    BITFLD.LONG 0x00 4. "             pub_deep_sleep ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "          ch1_dmc_phy_ca_en ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 6. "       ch1_dmc_phy_ag_rd_en ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "       ch1_dmc_phy_ag_wr_en ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "          ch1_dmc_phy_ag_en ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "          ch0_dmc_phy_ca_en ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "       ch0_dmc_phy_ag_rd_en ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "       ch0_dmc_phy_ag_wr_en ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "          ch0_dmc_phy_ag_en ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "                       1'b0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "             cgm_en_dmc_ch6 ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "             cgm_en_dmc_ch5 ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "             cgm_en_dmc_ch4 ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "             cgm_en_dmc_ch3 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "             cgm_en_dmc_ch2 ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "             cgm_en_dmc_ch1 ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "             cgm_en_dmc_ch0 ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "                       1'b0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "          axi_chn_stop_agcp ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "         axi_chn_stop_wtlcp ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "         axi_chn_stop_pubcp ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "           axi_chn_stop_aon ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "            axi_chn_stop_ap ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "           axi_chn_stop_isp ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "       axi_chn_stop_isp_raw ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "           axi_chn_stop_dpu ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 30. "           axi_chn_stop_gpu ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "           axi_chn_stop_cpu ," "0   ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.pub_dbg_info_add_2 @ pub_dbg_info_add_2"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 34(0x22)" 
    VARX 0x00 %l SWD.read(0x00220000)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_info_add_2 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "                 fv_release ," "0     ,%d..."
    BITFLD.LONG 0x00 1. "                 bv_release ," "0     ,%d..."
    BITFLD.LONG 0x00 2. "                     fv_req ," "0     ,%d..."
    BITFLD.LONG 0x00 3. "                     bv_req ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4.--6. " dfs_lp_ctrl_cur_state[2:0] ," "0x0   ,%x..."
    BITFLD.LONG 0x00 7. "               dmc_clk_stop ," "0     ,%d..."
    BITFLD.LONG 0x00 8. "          dmc_sleep_release ," "0     ,%d..."
    BITFLD.LONG 0x00 9. "                  dmc_sleep ," "0     ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10.--18. "      emc_ckg_ddl_adjs[8:0] ," "0x0   ,%x..."
    BITFLD.LONG 0x00 19.--20. "          emc_ckg_mode[1:0] ," "0x0   ,%x..."
    BITFLD.LONG 0x00 21.--24. "        emc_ckg_d2_sel[3:0] ," "0x0   ,%x..."
    BITFLD.LONG 0x00 25.--31. "           emc_ckg_sel[6:0] ," "0x0   ,%x..."
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.pub_dbg_info_add_3 @ pub_dbg_info_add_3"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 35(0x23)" 
    VARX 0x00 %l SWD.read(0x00230000)
    TEXTLINE ""
    LINE.LONG 0x00 " pub_dbg_info_add_3 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--7. "     gt_f_status[7:0] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 8. "         fv_st_change ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "         bv_st_change ," "0    ,%d..."
    BITFLD.LONG 0x00 10.--16. "       fv_st_all[6:0] ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 17.--23. "       bv_st_all[6:0] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 24.--27. " vote_next_state[3:0] ," "0x0  ,%x..."
    BITFLD.LONG 0x00 28.--31. "  vote_cur_state[3:0] ," "0x0  ,%x..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 64(0x40)" 
    VARX 0x00 %l SWD.read(0x00400000)
    TEXTLINE ""
    LINE.LONG 0x00 "  ,32'h0"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data0_axi0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 65(0x41)" 
    VARX 0x00 %l SWD.read(0x00410000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data0_axi0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "                   BREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 1. "                   RREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 2. "                   WREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 3. "                  ARREADY ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "                  AWREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 5.--7. "                     3'h0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 8. "                   BVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "                   RVALID ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "                   WVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "                  ARVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "                  AWVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 13.--15. "                     3'h0 ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--21. "               ar_cnt_reg ," "0    ,%d..."
    BITFLD.LONG 0x00 22.--26. "               aw_cnt_reg ," "0    ,%d..."
    BITFLD.LONG 0x00 27. "                     1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 28. " ch0_rfarb_bw_holdoff_ch0 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. " ch1_rfarb_bw_holdoff_ch0 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. " ch2_rfarb_bw_holdoff_ch0 ," "0    ,%d..."
    BITFLD.LONG 0x00 31. " ch3_rfarb_bw_holdoff_ch0 ," "0    ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_axi_ch0 @ rf_dbg_data1_axi0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 66(0x42)" 
    VARX 0x00 %l SWD.read(0x00420000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data1_axi0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "   rcmdbuf3_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "   rcmdbuf2_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "   rcmdbuf1_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "   rcmdbuf0_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "  rcmdbuf3_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "  rcmdbuf2_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "  rcmdbuf1_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "  rcmdbuf0_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. "      wbuf3_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "      wbuf2_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "      wbuf1_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "      wbuf0_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. "     wbuf3_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "     wbuf2_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "     wbuf1_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "     wbuf0_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. " wdatafifo_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  wdatafifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "    wcmdbuf_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "   wcmdbuf_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 20. "         CRACTIVE ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "         CWACTIVE ," "0   ,%d..."
    BITFLD.LONG 0x00 22.--23. "            2'b00 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24. "         s0_valid ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 25. "         s1_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "         s2_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "         s3_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "     dmc_sleep_ch ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. "      dmc_stop_ch ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "             1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "        wlast_err ," "0   ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data0_axi1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 67(0x43)" 
    VARX 0x00 %l SWD.read(0x00430000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data0_axi1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "                   BREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 1. "                   RREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 2. "                   WREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 3. "                  ARREADY ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "                  AWREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 5.--7. "                     3'h0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 8. "                   BVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "                   RVALID ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "                   WVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "                  ARVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "                  AWVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 13.--15. "                     3'h0 ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--21. "               ar_cnt_reg ," "0    ,%d..."
    BITFLD.LONG 0x00 22.--26. "               aw_cnt_reg ," "0    ,%d..."
    BITFLD.LONG 0x00 27. "                     1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 28. " ch0_rfarb_bw_holdoff_ch1 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. " ch1_rfarb_bw_holdoff_ch1 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. " ch2_rfarb_bw_holdoff_ch1 ," "0    ,%d..."
    BITFLD.LONG 0x00 31. " ch3_rfarb_bw_holdoff_ch1 ," "0    ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_axi_ch1 @ rf_dbg_data1_axi1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 68(0x44)" 
    VARX 0x00 %l SWD.read(0x00440000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data1_axi1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "   rcmdbuf3_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "   rcmdbuf2_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "   rcmdbuf1_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "   rcmdbuf0_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "  rcmdbuf3_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "  rcmdbuf2_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "  rcmdbuf1_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "  rcmdbuf0_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. "      wbuf3_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "      wbuf2_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "      wbuf1_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "      wbuf0_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. "     wbuf3_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "     wbuf2_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "     wbuf1_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "     wbuf0_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. " wdatafifo_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  wdatafifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "    wcmdbuf_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "   wcmdbuf_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 20. "         CRACTIVE ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "         CWACTIVE ," "0   ,%d..."
    BITFLD.LONG 0x00 22.--23. "            2'b00 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24. "         s0_valid ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 25. "         s1_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "         s2_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "         s3_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "     dmc_sleep_ch ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. "      dmc_stop_ch ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "             1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "        wlast_err ," "0   ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data0_axi2"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 69(0x45)" 
    VARX 0x00 %l SWD.read(0x00450000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data0_axi2 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "                   BREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 1. "                   RREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 2. "                   WREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 3. "                  ARREADY ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "                  AWREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 5.--7. "                     3'h0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 8. "                   BVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "                   RVALID ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "                   WVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "                  ARVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "                  AWVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 13.--15. "                     3'h0 ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--21. "               ar_cnt_reg ," "0    ,%d..."
    BITFLD.LONG 0x00 22.--26. "               aw_cnt_reg ," "0    ,%d..."
    BITFLD.LONG 0x00 27. "                     1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 28. " ch0_rfarb_bw_holdoff_ch2 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. " ch1_rfarb_bw_holdoff_ch2 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. " ch2_rfarb_bw_holdoff_ch2 ," "0    ,%d..."
    BITFLD.LONG 0x00 31. " ch3_rfarb_bw_holdoff_ch2 ," "0    ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_axi_ch2 @ rf_dbg_data1_axi2"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 70(0x46)" 
    VARX 0x00 %l SWD.read(0x00460000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data1_axi2 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "   rcmdbuf3_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "   rcmdbuf2_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "   rcmdbuf1_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "   rcmdbuf0_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "  rcmdbuf3_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "  rcmdbuf2_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "  rcmdbuf1_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "  rcmdbuf0_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. "      wbuf3_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "      wbuf2_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "      wbuf1_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "      wbuf0_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. "     wbuf3_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "     wbuf2_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "     wbuf1_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "     wbuf0_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. " wdatafifo_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  wdatafifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "    wcmdbuf_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "   wcmdbuf_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 20. "         CRACTIVE ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "         CWACTIVE ," "0   ,%d..."
    BITFLD.LONG 0x00 22.--23. "            2'b00 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24. "         s0_valid ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 25. "         s1_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "         s2_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "         s3_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "     dmc_sleep_ch ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. "      dmc_stop_ch ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "             1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "        wlast_err ," "0   ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data0_axi3"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 71(0x47)" 
    VARX 0x00 %l SWD.read(0x00470000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data0_axi3 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "                   BREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 1. "                   RREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 2. "                   WREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 3. "                  ARREADY ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "                  AWREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 5.--7. "                     3'h0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 8. "                   BVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "                   RVALID ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "                   WVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "                  ARVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "                  AWVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 13.--15. "                     3'h0 ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--21. "               ar_cnt_reg ," "0    ,%d..."
    BITFLD.LONG 0x00 22.--26. "               aw_cnt_reg ," "0    ,%d..."
    BITFLD.LONG 0x00 27. "                     1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 28. " ch0_rfarb_bw_holdoff_ch3 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. " ch1_rfarb_bw_holdoff_ch3 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. " ch2_rfarb_bw_holdoff_ch3 ," "0    ,%d..."
    BITFLD.LONG 0x00 31. " ch3_rfarb_bw_holdoff_ch3 ," "0    ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_axi_ch3 @ rf_dbg_data1_axi3"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 72(0x48)" 
    VARX 0x00 %l SWD.read(0x00480000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data1_axi3 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "   rcmdbuf3_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "   rcmdbuf2_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "   rcmdbuf1_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "   rcmdbuf0_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "  rcmdbuf3_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "  rcmdbuf2_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "  rcmdbuf1_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "  rcmdbuf0_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. "      wbuf3_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "      wbuf2_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "      wbuf1_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "      wbuf0_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. "     wbuf3_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "     wbuf2_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "     wbuf1_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "     wbuf0_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. " wdatafifo_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  wdatafifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "    wcmdbuf_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "   wcmdbuf_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 20. "         CRACTIVE ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "         CWACTIVE ," "0   ,%d..."
    BITFLD.LONG 0x00 22.--23. "            2'b00 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24. "         s0_valid ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 25. "         s1_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "         s2_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "         s3_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "     dmc_sleep_ch ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. "      dmc_stop_ch ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "             1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "        wlast_err ," "0   ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data0_axi4"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 73(0x49)" 
    VARX 0x00 %l SWD.read(0x00490000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data0_axi4 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "                   BREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 1. "                   RREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 2. "                   WREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 3. "                  ARREADY ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "                  AWREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 5.--7. "                     3'h0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 8. "                   BVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "                   RVALID ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "                   WVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "                  ARVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "                  AWVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 13.--15. "                     3'h0 ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--21. "               ar_cnt_reg ," "0    ,%d..."
    BITFLD.LONG 0x00 22.--26. "               aw_cnt_reg ," "0    ,%d..."
    BITFLD.LONG 0x00 27. "                     1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 28. " ch0_rfarb_bw_holdoff_ch4 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. " ch1_rfarb_bw_holdoff_ch4 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. " ch2_rfarb_bw_holdoff_ch4 ," "0    ,%d..."
    BITFLD.LONG 0x00 31. " ch3_rfarb_bw_holdoff_ch4 ," "0    ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_axi_ch4 @ rf_dbg_data1_axi4"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 74(0x4a)" 
    VARX 0x00 %l SWD.read(0x004A0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data1_axi4 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "   rcmdbuf3_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "   rcmdbuf2_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "   rcmdbuf1_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "   rcmdbuf0_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "  rcmdbuf3_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "  rcmdbuf2_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "  rcmdbuf1_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "  rcmdbuf0_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. "      wbuf3_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "      wbuf2_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "      wbuf1_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "      wbuf0_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. "     wbuf3_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "     wbuf2_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "     wbuf1_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "     wbuf0_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. " wdatafifo_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  wdatafifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "    wcmdbuf_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "   wcmdbuf_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 20. "         CRACTIVE ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "         CWACTIVE ," "0   ,%d..."
    BITFLD.LONG 0x00 22.--23. "            2'b00 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24. "         s0_valid ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 25. "         s1_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "         s2_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "         s3_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "     dmc_sleep_ch ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. "      dmc_stop_ch ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "             1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "        wlast_err ," "0   ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data0_axi5"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 75(0x4b)" 
    VARX 0x00 %l SWD.read(0x004B0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data0_axi5 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "                   BREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 1. "                   RREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 2. "                   WREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 3. "                  ARREADY ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "                  AWREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 5.--7. "                     3'h0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 8. "                   BVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "                   RVALID ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "                   WVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "                  ARVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "                  AWVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 13.--15. "                     3'h0 ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--21. "               ar_cnt_reg ," "0    ,%d..."
    BITFLD.LONG 0x00 22.--26. "               aw_cnt_reg ," "0    ,%d..."
    BITFLD.LONG 0x00 27. "                     1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 28. " ch0_rfarb_bw_holdoff_ch5 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. " ch1_rfarb_bw_holdoff_ch5 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. " ch2_rfarb_bw_holdoff_ch5 ," "0    ,%d..."
    BITFLD.LONG 0x00 31. " ch3_rfarb_bw_holdoff_ch5 ," "0    ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_axi_ch5 @ rf_dbg_data1_axi5"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 76(0x4c)" 
    VARX 0x00 %l SWD.read(0x004C0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data1_axi5 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "   rcmdbuf3_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "   rcmdbuf2_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "   rcmdbuf1_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "   rcmdbuf0_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "  rcmdbuf3_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "  rcmdbuf2_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "  rcmdbuf1_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "  rcmdbuf0_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. "      wbuf3_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "      wbuf2_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "      wbuf1_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "      wbuf0_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. "     wbuf3_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "     wbuf2_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "     wbuf1_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "     wbuf0_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. " wdatafifo_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  wdatafifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "    wcmdbuf_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "   wcmdbuf_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 20. "         CRACTIVE ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "         CWACTIVE ," "0   ,%d..."
    BITFLD.LONG 0x00 22.--23. "            2'b00 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24. "         s0_valid ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 25. "         s1_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "         s2_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "         s3_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "     dmc_sleep_ch ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. "      dmc_stop_ch ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "             1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "        wlast_err ," "0   ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data0_axi6"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 77(0x4d)" 
    VARX 0x00 %l SWD.read(0x004D0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data0_axi6 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "                   BREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 1. "                   RREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 2. "                   WREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 3. "                  ARREADY ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "                  AWREADY ," "0    ,%d..."
    BITFLD.LONG 0x00 5.--7. "                     3'h0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 8. "                   BVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "                   RVALID ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "                   WVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "                  ARVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 12. "                  AWVALID ," "0    ,%d..."
    BITFLD.LONG 0x00 13.--15. "                     3'h0 ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--21. "               ar_cnt_reg ," "0    ,%d..."
    BITFLD.LONG 0x00 22.--26. "               aw_cnt_reg ," "0    ,%d..."
    BITFLD.LONG 0x00 27. "                     1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 28. " ch0_rfarb_bw_holdoff_ch6 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. " ch1_rfarb_bw_holdoff_ch6 ," "0    ,%d..."
    BITFLD.LONG 0x00 30. " ch2_rfarb_bw_holdoff_ch6 ," "0    ,%d..."
    BITFLD.LONG 0x00 31. " ch3_rfarb_bw_holdoff_ch6 ," "0    ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_axi_ch6 @ rf_dbg_data1_axi6"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 78(0x4e)" 
    VARX 0x00 %l SWD.read(0x004E0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data1_axi6 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "   rcmdbuf3_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "   rcmdbuf2_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "   rcmdbuf1_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "   rcmdbuf0_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "  rcmdbuf3_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "  rcmdbuf2_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "  rcmdbuf1_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "  rcmdbuf0_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. "      wbuf3_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "      wbuf2_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "      wbuf1_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "      wbuf0_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. "     wbuf3_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "     wbuf2_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "     wbuf1_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "     wbuf0_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. " wdatafifo_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "  wdatafifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "    wcmdbuf_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "   wcmdbuf_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 20. "         CRACTIVE ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "         CWACTIVE ," "0   ,%d..."
    BITFLD.LONG 0x00 22.--23. "            2'b00 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24. "         s0_valid ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 25. "         s1_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "         s2_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "         s3_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "     dmc_sleep_ch ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. "      dmc_stop_ch ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "             1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "        wlast_err ," "0   ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data0_axi7"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 79(0x4f)" 
    VARX 0x00 %l SWD.read(0x004F0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data0_axi7 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " 1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 1. " 1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 2. " 1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 3. " 1'b0 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. " 1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 5.--7. " 1'b0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 8. " 1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 9. " 1'b0 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. " 1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 11. " 1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 12. " 1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 13.--15. " 1'b0 ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--21. " 1'b0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 22.--27. " 1'b0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 28. " 1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 29. " 1'b0 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 30. " 1'b0 ," "0    ,%d..."
    BITFLD.LONG 0x00 31. " 1'b0 ," "0    ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data1_axi7"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 80(0x50)" 
    VARX 0x00 %l SWD.read(0x00500000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data1_axi7 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 1. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 3. " 1'b0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 5. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 6. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 7. " 1'b0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 9. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 10. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 11. " 1'b0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 13. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 14. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 15. " 1'b0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 17. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 18. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 19. " 1'b0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 20. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 21. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 22.--23. " 1'b0 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24. " 1'b0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 25. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 26. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 27. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 28. " 1'b0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 30. " 1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 31. " 1'b0 ," "0   ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_cmdq_ch0 @ rf_dbg_data0_cmdq_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 81(0x51)" 
    VARX 0x00 %l SWD.read(0x00510000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data0_cmdq_ch0 ,Valid[31:0]"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_cmdq_ch0 @ rf_dbg_data1_cmdq_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 82(0x52)" 
    VARX 0x00 %l SWD.read(0x00520000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data1_cmdq_ch0 ,valid[63:32]"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_cmdq_ch0 @ rf_dbg_data2_cmdq_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 83(0x53)" 
    VARX 0x00 %l SWD.read(0x00530000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data2_cmdq_ch0 ,valid_r[31:0]"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_cmdq_ch0 @ rf_dbg_data3_cmdq_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 84(0x54)" 
    VARX 0x00 %l SWD.read(0x00540000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data3_cmdq_ch0 ,valid_r[63:32]"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_cmdq_ch0 @ rf_dbg_data4_cmdq_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 85(0x55)" 
    VARX 0x00 %l SWD.read(0x00550000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data4_cmdq_ch0 ,ddr_sts[31:0]"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_cmdq_ch0 @ rf_dbg_data5_cmdq_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 86(0x56)" 
    VARX 0x00 %l SWD.read(0x00560000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data5_cmdq_ch0 ,ddr_sts[63:32]"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_cmdq_ch0 @ rf_dbg_data6_cmdq_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 87(0x57)" 
    VARX 0x00 %l SWD.read(0x00570000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data6_cmdq_ch0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--15. "            ba_valid ," "0x0    ,%x..."
    BITFLD.LONG 0x00 16. "              cur_wr ," "0      ,%d..."
    BITFLD.LONG 0x00 17. "           mask_wpre ," "0      ,%d..."
    BITFLD.LONG 0x00 18. "              mask_w ," "0      ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "  max_write_cnt_done ," "0      ,%d..."
    BITFLD.LONG 0x00 20. "   max_read_cnt_done ," "0      ,%d..."
    BITFLD.LONG 0x00 21.--22. " i_dmem_cs_busy[1:0] ," "0x0    ,%x..."
    BITFLD.LONG 0x00 23. "    i_dmem_cmdb_busy ," "0      ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. "                8'h0 ," "0x0    ,%x..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_cmdq_ch0 @ rf_dbg_data7_cmdq_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 88(0x58)" 
    VARX 0x00 %l SWD.read(0x00580000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data7_cmdq_ch0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "  o_dmem_actfifo_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 1. " o_dmem_pre0fifo_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " o_dmem_pre1fifo_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "  o_dmem_reffifo_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "   o_dmem_rwfifo_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 5.--7. "                   3'h0 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 8. "          actfifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "         pre0fifo_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "         pre1fifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "          reffifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "           rwfifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "        raddrfifo_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "        waddrfifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "                   1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "         actfifo_rerror ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "        pre0fifo_rerror ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "        pre1fifo_rerror ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "         reffifo_rerror ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "          rwfifo_rerror ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "       raddrfifo_rerror ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "       waddrfifo_rerror ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "                   1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "         actfifo_werror ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "        pre0fifo_werror ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "        pre1fifo_werror ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "         reffifo_werror ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "          rwfifo_werror ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "       raddrfifo_werror ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 30. "       waddrfifo_werror ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "                   1'b0 ," "0   ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data_carb_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 89(0x59)" 
    VARX 0x00 %l SWD.read(0x00590000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data_carb_ch0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "   cmdfifo_rempty ," "0    ,%d..."
    BITFLD.LONG 0x00 1. "    cmdfifo_wfull ," "0    ,%d..."
    BITFLD.LONG 0x00 2. "   cmdfifo_rerror ," "0    ,%d..."
    BITFLD.LONG 0x00 3. "   cmdfifo_werror ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "        rbuf_full ," "0    ,%d..."
    BITFLD.LONG 0x00 5. "        wbuf_full ," "0    ,%d..."
    BITFLD.LONG 0x00 6. " drf_dfs_bus_hold ," "0    ,%d..."
    BITFLD.LONG 0x00 7. "      lp_dfs_busy ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. "   axi_req_rd_ch0 ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "   axi_req_rd_ch1 ," "0    ,%d..."
    BITFLD.LONG 0x00 10. "   axi_req_rd_ch2 ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "   axi_req_rd_ch3 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. "   axi_req_rd_ch4 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "   axi_req_rd_ch5 ," "0    ,%d..."
    BITFLD.LONG 0x00 14. "   axi_req_rd_ch6 ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "   axi_req_rd_ch7 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "   axi_req_wr_ch0 ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "   axi_req_wr_ch1 ," "0    ,%d..."
    BITFLD.LONG 0x00 18. "   axi_req_wr_ch2 ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "   axi_req_wr_ch3 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 20. "   axi_req_wr_ch4 ," "0    ,%d..."
    BITFLD.LONG 0x00 21. "   axi_req_wr_ch5 ," "0    ,%d..."
    BITFLD.LONG 0x00 22. "   axi_req_wr_ch6 ," "0    ,%d..."
    BITFLD.LONG 0x00 23. "   axi_req_wr_ch7 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. "             8'h0 ," "0x0  ,%x..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_dmem_ch0 @ rf_dbg_data0_dmem_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 90(0x5a)" 
    VARX 0x00 %l SWD.read(0x005A0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data0_dmem_ch0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--3. "  rfdmem_cs0_st ," "0x0  ,%x..."
    BITFLD.LONG 0x00 4.--7. "  rfdmem_cs1_st ," "0x0  ,%x..."
    BITFLD.LONG 0x00 8.--12. " rfdmem_cmdb_st ," "0x0  ,%x..."
    BITFLD.LONG 0x00 13.--15. "           3'h0 ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--20. " rflp_dfs_state ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21.--23. "           3'h0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 24.--31. "         dfi_st ," "0x0  ,%x..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_dmem_ch0 @ rf_dbg_data1_dmem_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 91(0x5b)" 
    VARX 0x00 %l SWD.read(0x005B0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data1_dmem_ch0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "    dmc_lp_cmd_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "          dmc_lp_req ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "          dmc_lp_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "         dmc_lp_done ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4.--6. "      dmc_lp_reg_sel ," "0x0 ,%x..."
    BITFLD.LONG 0x00 7. "                1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "         rfdmem_idle ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "  dmem_idle_comb4dfs ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "            dmc_stop ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "           dmc_sleep ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "     dmc_force_sleep ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "           dsoft_cmd ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14.--15. "               2'b00 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 16.--19. " rfdmem_ref_rate_cs0 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 20.--23. " rfdmem_ref_rate_cs1 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24. "   dfi_init_complete ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 25. "  dfi_init_start_dly ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "      dfi_init_start ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      dfi_phyupd_req ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      dfi_phyupd_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. "     dfi_ctrlupd_req ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "     dfi_ctrlupd_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "                1'b0 ," "0   ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_wbuf_ch0 @ rf_dbg_data0_wbuf_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 92(0x5c)" 
    VARX 0x00 %l SWD.read(0x005C0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data0_wbuf_ch0 ,wbuf0_valid_r"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_wbuf_ch0 @ rf_dbg_data1_wbuf_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 93(0x5d)" 
    VARX 0x00 %l SWD.read(0x005D0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data1_wbuf_ch0 ,wbuf1_wvalid_r"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_wbuf_ch0 @ rf_dbg_data2_wbuf_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 94(0x5e)" 
    VARX 0x00 %l SWD.read(0x005E0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data2_wbuf_ch0 ,wbuf1_cvalid_r"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl.u_dmc_wbuf_ch0 @ rf_dbg_data3_wbuf_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 95(0x5f)" 
    VARX 0x00 %l SWD.read(0x005F0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data3_wbuf_ch0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--5. " wbuf0_cnt_r ," "0    ,%d..."
    BITFLD.LONG 0x00 6.--7. "       2'b00 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 8.--13. " wbuf1_cnt_r ," "0    ,%d..."
    BITFLD.LONG 0x00 14.--15. "       2'b00 ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--17. " wdata_cnt_r ," "0    ,%d..."
    BITFLD.LONG 0x00 18.--23. "        6'h0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 24.--31. "        8'h0 ," "0x0  ,%x..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data0_rbuf_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 96(0x60)" 
    VARX 0x00 %l SWD.read(0x00600000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data0_rbuf_ch0 ,rbuf_rvalid_r[31:0]"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data1_rbuf_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 97(0x61)" 
    VARX 0x00 %l SWD.read(0x00610000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data1_rbuf_ch0 ,rbuf_rvalid_r[63:32]"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data2_rbuf_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 98(0x62)" 
    VARX 0x00 %l SWD.read(0x00620000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data2_rbuf_ch0 ,rbuf0_cvalid_r"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data3_rbuf_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 99(0x63)" 
    VARX 0x00 %l SWD.read(0x00630000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data3_rbuf_ch0 ,rbuf1_cvalid_r"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data4_rbuf_ch0"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 100(0x64)" 
    VARX 0x00 %l SWD.read(0x00640000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data4_rbuf_ch0 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--5. " rbuf0_cnt_r ," "0    ,%d..."
    BITFLD.LONG 0x00 6.--7. "       2'b00 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 8.--13. " rbuf1_cnt_r ," "0    ,%d..."
    BITFLD.LONG 0x00 14.--15. "       2'b00 ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--17. " rdata_cnt_r ," "0    ,%d..."
    BITFLD.LONG 0x00 18.--23. "        6'h0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 24.--31. "        8'h0 ," "0x0  ,%x..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data0_cmdq_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 101(0x65)" 
    VARX 0x00 %l SWD.read(0x00650000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data0_cmdq_ch1 ,Valid[31:0]"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data1_cmdq_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 102(0x66)" 
    VARX 0x00 %l SWD.read(0x00660000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data1_cmdq_ch1 ,valid[63:32]"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data2_cmdq_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 103(0x67)" 
    VARX 0x00 %l SWD.read(0x00670000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data2_cmdq_ch1 ,valid_r[31:0]"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data3_cmdq_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 104(0x68)" 
    VARX 0x00 %l SWD.read(0x00680000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data3_cmdq_ch1 ,valid_r[63:32]"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data4_cmdq_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 105(0x69)" 
    VARX 0x00 %l SWD.read(0x00690000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data4_cmdq_ch1 ,ddr_sts[31:0]"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data5_cmdq_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 106(0x6a)" 
    VARX 0x00 %l SWD.read(0x006A0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data5_cmdq_ch1 ,ddr_sts[63:32]"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data6_cmdq_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 107(0x6b)" 
    VARX 0x00 %l SWD.read(0x006B0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data6_cmdq_ch1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--15. "            ba_valid ," "0x0    ,%x..."
    BITFLD.LONG 0x00 16. "              cur_wr ," "0      ,%d..."
    BITFLD.LONG 0x00 17. "           mask_wpre ," "0      ,%d..."
    BITFLD.LONG 0x00 18. "              mask_w ," "0      ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "  max_write_cnt_done ," "0      ,%d..."
    BITFLD.LONG 0x00 20. "   max_read_cnt_done ," "0      ,%d..."
    BITFLD.LONG 0x00 21.--22. " i_dmem_cs_busy[1:0] ," "0x0    ,%x..."
    BITFLD.LONG 0x00 23. "    i_dmem_cmdb_busy ," "0      ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. "                8'h0 ," "0x0    ,%x..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data7_cmdq_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 108(0x6c)" 
    VARX 0x00 %l SWD.read(0x006C0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data7_cmdq_ch1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "  o_dmem_actfifo_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 1. " o_dmem_pre0fifo_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 2. " o_dmem_pre1fifo_rempty ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "  o_dmem_reffifo_rempty ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "     max_write_cnt_done ," "0   ,%d..."
    BITFLD.LONG 0x00 5.--7. "                   3'h0 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 8. "          actfifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "         pre0fifo_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "         pre1fifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "          reffifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "           rwfifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "        raddrfifo_wfull ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "        waddrfifo_wfull ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "                   1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "         actfifo_rerror ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "        pre0fifo_rerror ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "        pre1fifo_rerror ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "         reffifo_rerror ," "0   ,%d..."
    BITFLD.LONG 0x00 20. "          rwfifo_rerror ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "       raddrfifo_rerror ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 22. "       waddrfifo_rerror ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "                   1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 24. "         actfifo_werror ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "        pre0fifo_werror ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 26. "        pre1fifo_werror ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "         reffifo_werror ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "          rwfifo_werror ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "       raddrfifo_werror ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 30. "       waddrfifo_werror ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "                   1'b0 ," "0   ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data7_carb_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 109(0x6d)" 
    VARX 0x00 %l SWD.read(0x006D0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data7_carb_ch1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "   cmdfifo_rempty ," "0    ,%d..."
    BITFLD.LONG 0x00 1. "    cmdfifo_wfull ," "0    ,%d..."
    BITFLD.LONG 0x00 2. "   cmdfifo_rerror ," "0    ,%d..."
    BITFLD.LONG 0x00 3. "   cmdfifo_werror ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "        rbuf_full ," "0    ,%d..."
    BITFLD.LONG 0x00 5. "        wbuf_full ," "0    ,%d..."
    BITFLD.LONG 0x00 6. " drf_dfs_bus_hold ," "0    ,%d..."
    BITFLD.LONG 0x00 7. "      lp_dfs_busy ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. "   axi_req_rd_ch0 ," "0    ,%d..."
    BITFLD.LONG 0x00 9. "   axi_req_rd_ch1 ," "0    ,%d..."
    BITFLD.LONG 0x00 10. "   axi_req_rd_ch2 ," "0    ,%d..."
    BITFLD.LONG 0x00 11. "   axi_req_rd_ch3 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. "   axi_req_rd_ch4 ," "0    ,%d..."
    BITFLD.LONG 0x00 13. "   axi_req_rd_ch5 ," "0    ,%d..."
    BITFLD.LONG 0x00 14. "   axi_req_rd_ch6 ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "   axi_req_rd_ch7 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "   axi_req_wr_ch0 ," "0    ,%d..."
    BITFLD.LONG 0x00 17. "   axi_req_wr_ch1 ," "0    ,%d..."
    BITFLD.LONG 0x00 18. "   axi_req_wr_ch2 ," "0    ,%d..."
    BITFLD.LONG 0x00 19. "   axi_req_wr_ch3 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 20. "   axi_req_wr_ch4 ," "0    ,%d..."
    BITFLD.LONG 0x00 21. "   axi_req_wr_ch5 ," "0    ,%d..."
    BITFLD.LONG 0x00 22. "   axi_req_wr_ch6 ," "0    ,%d..."
    BITFLD.LONG 0x00 23. "   axi_req_wr_ch7 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 24.--31. "             8'h0 ," "0x0  ,%x..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data0_dmem_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 110(0x6e)" 
    VARX 0x00 %l SWD.read(0x006E0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data0_dmem_ch1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--3. "  rfdmem_cs0_st ," "0x0  ,%x..."
    BITFLD.LONG 0x00 4.--7. "  rfdmem_cs1_st ," "0x0  ,%x..."
    BITFLD.LONG 0x00 8.--12. " rfdmem_cmdb_st ," "0x0  ,%x..."
    BITFLD.LONG 0x00 13.--15. "           3'h0 ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--20. " rflp_dfs_state ," "0x0  ,%x..."
    BITFLD.LONG 0x00 21.--23. "           3'h0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 24.--31. "         dfi_st ," "0x0  ,%x..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data1_dmem_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 111(0x6f)" 
    VARX 0x00 %l SWD.read(0x006F0000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data1_dmem_ch1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "    dmc_lp_cmd_valid ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "          dmc_lp_req ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "          dmc_lp_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "         dmc_lp_done ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4.--6. "      dmc_lp_reg_sel ," "0x0 ,%x..."
    BITFLD.LONG 0x00 7. "                1'b0 ," "0   ,%d..."
    BITFLD.LONG 0x00 8. "         rfdmem_idle ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "  dmem_idle_comb4dfs ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 10. "            dmc_stop ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "           dmc_sleep ," "0   ,%d..."
    BITFLD.LONG 0x00 12. "     dmc_force_sleep ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "           dsoft_cmd ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14.--15. "               2'b00 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 16.--19. " rfdmem_ref_rate_cs0 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 20.--23. " rfdmem_ref_rate_cs1 ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24. "   dfi_init_complete ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 25. "  dfi_init_start_dly ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "      dfi_init_start ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "      dfi_phyupd_req ," "0   ,%d..."
    BITFLD.LONG 0x00 28. "      dfi_phyupd_ack ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 29. "     dfi_ctrlupd_req ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "     dfi_ctrlupd_ack ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "                1'b0 ," "0   ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data0_wbuf_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 112(0x70)" 
    VARX 0x00 %l SWD.read(0x00700000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data0_wbuf_ch1 ,wbuf0_valid_r"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data1_wbuf_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 113(0x71)" 
    VARX 0x00 %l SWD.read(0x00710000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data1_wbuf_ch1 ,wbuf1_wvalid_r"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data2_wbuf_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 114(0x72)" 
    VARX 0x00 %l SWD.read(0x00720000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data2_wbuf_ch1 ,wbuf1_cvalid_r"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data3_wbuf_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 115(0x73)" 
    VARX 0x00 %l SWD.read(0x00730000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data3_wbuf_ch1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--5. " wbuf0_cnt_r ," "0    ,%d..."
    BITFLD.LONG 0x00 6.--7. "       2'b00 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 8.--13. " wbuf1_cnt_r ," "0    ,%d..."
    BITFLD.LONG 0x00 14.--15. "       2'b00 ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--17. " wdata_cnt_r ," "0    ,%d..."
    BITFLD.LONG 0x00 18.--23. "        6'h0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 24.--31. "        8'h0 ," "0x0  ,%x..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data0_rbuf_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 116(0x74)" 
    VARX 0x00 %l SWD.read(0x00740000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data0_rbuf_ch1 ,rbuf_rvalid_r[31:0]"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data1_rbuf_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 117(0x75)" 
    VARX 0x00 %l SWD.read(0x00750000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data1_rbuf_ch1 ,rbuf_rvalid_r[63:32]"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data2_rbuf_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 118(0x76)" 
    VARX 0x00 %l SWD.read(0x00760000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data2_rbuf_ch1 ,rbuf0_cvalid_r"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data3_rbuf_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 119(0x77)" 
    VARX 0x00 %l SWD.read(0x00770000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data3_rbuf_ch1 ,rbuf1_cvalid_r"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_top.u_dmc_ctrl @ rf_dbg_data4_rbuf_ch1"
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 120(0x78)" 
    VARX 0x00 %l SWD.read(0x00780000)
    TEXTLINE ""
    LINE.LONG 0x00 " rf_dbg_data4_rbuf_ch1 "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--5. " rbuf0_cnt_r ," "0    ,%d..."
    BITFLD.LONG 0x00 6.--7. "       2'b00 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 8.--13. " rbuf1_cnt_r ," "0    ,%d..."
    BITFLD.LONG 0x00 14.--15. "       2'b00 ," "0x0  ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--17. " rdata_cnt_r ," "0    ,%d..."
    BITFLD.LONG 0x00 18.--23. "        6'h0 ," "0x0  ,%x..."
    BITFLD.LONG 0x00 24.--31. "        8'h0 ," "0x0  ,%x..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_top_ch0 @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 128(0x80)" 
    VARX 0x00 %l SWD.read(0x00800000)
    TEXTLINE ""
    LINE.LONG 0x00 "  ,32'h0"
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_top_ch0 @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 129(0x81)" 
    VARX 0x00 %l SWD.read(0x00810000)
    TEXTLINE ""
    LINE.LONG 0x00 "  "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "   dfi_rddata_valid_w0_phya[0] ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "   dfi_rddata_valid_w1_phya[0] ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "           dfi_addr_p0_phya[0] ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. "           dfi_addr_p1_phya[0] ," "0   ,%d..."
    BITFLD.LONG 0x00 4.--5. "         dfi_cs_n_p0_phya[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 6.--7. "         dfi_cs_n_p1_phya[1:0] ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8.--9. "    dfi_rddata_en_p0_phya[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 10.--11. "    dfi_rddata_en_p1_phya[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 12. "         dfi_rddata_w0_phya[0] ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 13. "         dfi_rddata_w0_phya[8] ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "        dfi_rddata_w0_phya[16] ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "        dfi_rddata_w0_phya[24] ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "         dfi_rddata_w1_phya[0] ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "         dfi_rddata_w1_phya[8] ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "        dfi_rddata_w1_phya[16] ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "        dfi_rddata_w1_phya[24] ," "0   ,%d..."
    BITFLD.LONG 0x00 20.--23. " dfi_rddata_dbi_n_w0_phya[3:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24.--27. " dfi_rddata_dbi_n_w1_phya[3:0] ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 28. "          dfi_ctrlupd_ack_phya ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "          dfi_ctrlupd_req_phya ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "           dfi_phyupd_ack_phya ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "           dfi_phyupd_req_phya ," "0   ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_top_ch0 @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 130(0x82)" 
    VARX 0x00 %l SWD.read(0x00820000)
    TEXTLINE ""
    LINE.LONG 0x00 "  "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "   dfi_rddata_valid_w0_phyb[0] ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "   dfi_rddata_valid_w1_phyb[0] ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "           dfi_addr_p0_phyb[0] ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 3. "           dfi_addr_p1_phyb[0] ," "0   ,%d..."
    BITFLD.LONG 0x00 4.--5. "         dfi_cs_n_p0_phyb[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 6.--7. "         dfi_cs_n_p1_phyb[1:0] ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8.--9. "    dfi_rddata_en_p0_phyb[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 10.--11. "    dfi_rddata_en_p1_phyb[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 12. "         dfi_rddata_w0_phyb[0] ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 13. "         dfi_rddata_w0_phyb[8] ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "        dfi_rddata_w0_phyb[16] ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "        dfi_rddata_w0_phyb[24] ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "         dfi_rddata_w1_phyb[0] ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "         dfi_rddata_w1_phyb[8] ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "        dfi_rddata_w1_phyb[16] ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 19. "        dfi_rddata_w1_phyb[24] ," "0   ,%d..."
    BITFLD.LONG 0x00 20.--23. " dfi_rddata_dbi_n_w0_phyb[3:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24.--27. " dfi_rddata_dbi_n_w1_phyb[3:0] ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 28. "          dfi_ctrlupd_ack_phyb ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "          dfi_ctrlupd_req_phyb ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "           dfi_phyupd_ack_phyb ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "           dfi_phyupd_req_phyb ," "0   ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_top_ch0 @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 131(0x83)" 
    VARX 0x00 %l SWD.read(0x00830000)
    TEXTLINE ""
    LINE.LONG 0x00 "  "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--1. "      dfi_addr_p0_phya[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 2.--3. "      dfi_addr_p1_phya[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 4.--5. "      dfi_cs_n_p0_phya[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 6.--7. "      dfi_cs_n_p1_phya[1:0] ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8.--9. " dfi_wrdata_en_p0_phya[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 10.--11. " dfi_wrdata_en_p1_phya[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 12. "      dfi_wrdata_p0_phya[0] ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "      dfi_wrdata_p0_phya[8] ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "     dfi_wrdata_p0_phya[16] ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "     dfi_wrdata_p0_phya[24] ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "      dfi_wrdata_p1_phya[0] ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "      dfi_wrdata_p1_phya[8] ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "     dfi_wrdata_p1_phya[16] ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "     dfi_wrdata_p1_phya[24] ," "0   ,%d..."
    BITFLD.LONG 0x00 20.--23. "    dfi_wrmask_p0_phya[3:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24.--27. "    dfi_wrmask_p1_phya[3:0] ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 28. "       dfi_ctrlupd_ack_phya ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "       dfi_ctrlupd_req_phya ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "        dfi_phyupd_ack_phya ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "        dfi_phyupd_req_phya ," "0   ,%d..."
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_top_ch0 @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 132(0x84)" 
    VARX 0x00 %l SWD.read(0x00840000)
    TEXTLINE ""
    LINE.LONG 0x00 "  "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--1. "      dfi_addr_p0_phyb[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 2.--3. "      dfi_addr_p1_phyb[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 4.--5. "      dfi_cs_n_p0_phyb[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 6.--7. "      dfi_cs_n_p1_phyb[1:0] ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8.--9. " dfi_wrdata_en_p0_phyb[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 10.--11. " dfi_wrdata_en_p1_phyb[1:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 12. "      dfi_wrdata_p0_phyb[0] ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "      dfi_wrdata_p0_phyb[8] ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 14. "     dfi_wrdata_p0_phyb[16] ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "     dfi_wrdata_p0_phyb[24] ," "0   ,%d..."
    BITFLD.LONG 0x00 16. "      dfi_wrdata_p1_phyb[0] ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "      dfi_wrdata_p1_phyb[8] ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 18. "     dfi_wrdata_p1_phyb[16] ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "     dfi_wrdata_p1_phyb[24] ," "0   ,%d..."
    BITFLD.LONG 0x00 20.--23. "    dfi_wrmask_p0_phyb[3:0] ," "0x0 ,%x..."
    BITFLD.LONG 0x00 24.--27. "    dfi_wrmask_p1_phyb[3:0] ," "0x0 ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 28. "       dfi_ctrlupd_ack_phyb ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "       dfi_ctrlupd_req_phyb ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "        dfi_phyupd_ack_phyb ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "        dfi_phyupd_req_phyb ," "0   ,%d..."
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_top_ch0 @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 133(0x85)" 
    VARX 0x00 %l SWD.read(0x00850000)
    TEXTLINE ""
    LINE.LONG 0x00 "  "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. "       rfdll_locked_ds3 ," "0   ,%d..."
    BITFLD.LONG 0x00 1. "       rfdll_locked_ds2 ," "0   ,%d..."
    BITFLD.LONG 0x00 2. "       rfdll_locked_ds1 ," "0   ,%d..."
    BITFLD.LONG 0x00 3. "       rfdll_locked_ds0 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4. "       rfdll_locked_ac1 ," "0   ,%d..."
    BITFLD.LONG 0x00 5. "       rfdll_locked_ac0 ," "0   ,%d..."
    BITFLD.LONG 0x00 6. "   rf_dl_cpst_start_ds3 ," "0   ,%d..."
    BITFLD.LONG 0x00 7. "   rf_dl_cpst_start_ds2 ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8. "   rf_dl_cpst_start_ds1 ," "0   ,%d..."
    BITFLD.LONG 0x00 9. "   rf_dl_cpst_start_ds0 ," "0   ,%d..."
    BITFLD.LONG 0x00 10. "     dmc_phy_dskpll_rst ," "0   ,%d..."
    BITFLD.LONG 0x00 11. "      dmc_phy_dskpll_pd ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 12. "     dmc_phy_pll_locked ," "0   ,%d..."
    BITFLD.LONG 0x00 13. "      dmc_phy_pll_ready ," "0   ,%d..."
    BITFLD.LONG 0x00 14. "          rst_dmc_phy_n ," "0   ,%d..."
    BITFLD.LONG 0x00 15. "         clk_dmc_phy_4x ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16. "             clk_dmc_4x ," "0   ,%d..."
    BITFLD.LONG 0x00 17. "                clk_dmc ," "0   ,%d..."
    BITFLD.LONG 0x00 18. "         pd_dmc_phy_iso ," "0   ,%d..."
    BITFLD.LONG 0x00 19. "           dmc_pd_latch ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 20. " dfi_init_complete_phyb ," "0   ,%d..."
    BITFLD.LONG 0x00 21. "    dfi_init_start_phyb ," "0   ,%d..."
    BITFLD.LONG 0x00 22. " dfi_init_complete_phya ," "0   ,%d..."
    BITFLD.LONG 0x00 23. "    dfi_init_start_phya ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 24. "   dfi_ctrlupd_ack_phyb ," "0   ,%d..."
    BITFLD.LONG 0x00 25. "   dfi_ctrlupd_req_phyb ," "0   ,%d..."
    BITFLD.LONG 0x00 26. "    dfi_phyupd_ack_phyb ," "0   ,%d..."
    BITFLD.LONG 0x00 27. "    dfi_phyupd_req_phyb ," "0   ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 28. "   dfi_ctrlupd_ack_phya ," "0   ,%d..."
    BITFLD.LONG 0x00 29. "   dfi_ctrlupd_req_phya ," "0   ,%d..."
    BITFLD.LONG 0x00 30. "    dfi_phyupd_ack_phya ," "0   ,%d..."
    BITFLD.LONG 0x00 31. "    dfi_phyupd_req_phya ," "0   ,%d..."
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_top_ch0 @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 134(0x86)" 
    VARX 0x00 %l SWD.read(0x00860000)
    TEXTLINE ""
    LINE.LONG 0x00 "  "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " dfi_rddata_valid_w0_phya[0] ," "0      ,%d..."
    BITFLD.LONG 0x00 1. " dfi_rddata_valid_w1_phya[0] ," "0      ,%d..."
    BITFLD.LONG 0x00 2.--3. "       dfi_cs_n_p0_phya[1:0] ," "0x0    ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4.--5. "       dfi_cs_n_p1_phya[1:0] ," "0x0    ,%x..."
    BITFLD.LONG 0x00 6. "    dfi_rddata_en_p0_phya[0] ," "0      ,%d..."
    BITFLD.LONG 0x00 7. "    dfi_rddata_en_p1_phya[0] ," "0      ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8.--23. "        pad_in_dmc_d_n[15:0] ," "0x0    ,%x..."
    BITFLD.LONG 0x00 24.--25. "       pad_in_dmc_dqs_s[1:0] ," "0x0    ,%x..."
    BITFLD.LONG 0x00 26.--27. "       pad_in_dmc_dqm_n[1:0] ," "0x0    ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 28. "        dfi_ctrlupd_ack_phya ," "0      ,%d..."
    BITFLD.LONG 0x00 29. "        dfi_ctrlupd_req_phya ," "0      ,%d..."
    BITFLD.LONG 0x00 30. "         dfi_phyupd_ack_phya ," "0      ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "         dfi_phyupd_req_phya ," "0      ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_top_ch0 @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 135(0x87)" 
    VARX 0x00 %l SWD.read(0x00870000)
    TEXTLINE ""
    LINE.LONG 0x00 "  "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0. " dfi_rddata_valid_w0_phyb[0] ," "0      ,%d..."
    BITFLD.LONG 0x00 1. " dfi_rddata_valid_w1_phyb[0] ," "0      ,%d..."
    BITFLD.LONG 0x00 2.--3. "       dfi_cs_n_p0_phyb[1:0] ," "0x0    ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 4.--5. "       dfi_cs_n_p1_phyb[1:0] ," "0x0    ,%x..."
    BITFLD.LONG 0x00 6. "    dfi_rddata_en_p0_phyb[0] ," "0      ,%d..."
    BITFLD.LONG 0x00 7. "    dfi_rddata_en_p1_phyb[0] ," "0      ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 8.--23. "       pad_in_dmc_d_n[31:16] ," "0x0    ,%x..."
    BITFLD.LONG 0x00 24.--25. "       pad_in_dmc_dqs_s[3:2] ," "0x0    ,%x..."
    BITFLD.LONG 0x00 26.--27. "       pad_in_dmc_dqm_n[3:2] ," "0x0    ,%x..."
    TEXTLINE ""
    BITFLD.LONG 0x00 28. "        dfi_ctrlupd_ack_phyb ," "0      ,%d..."
    BITFLD.LONG 0x00 29. "        dfi_ctrlupd_req_phyb ," "0      ,%d..."
    BITFLD.LONG 0x00 30. "         dfi_phyupd_ack_phyb ," "0      ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 31. "         dfi_phyupd_req_phyb ," "0      ,%d..."
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_top_ch0 @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 136(0x88)" 
    VARX 0x00 %l SWD.read(0x00880000)
    TEXTLINE ""
    LINE.LONG 0x00 "  "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--6. " rfdll_min_cnt_f0_ac0[6:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 7. "       rfdll_min_pulse_ac0 ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--14. " rfdll_max_cnt_f0_ac0[6:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "       rfdll_max_pulse_ac0 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--22. " rfdll_min_cnt_f1_ac0[6:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 23. "       rfdll_min_pulse_ac0 ," "0    ,%d..."
    BITFLD.LONG 0x00 24.--30. " rfdll_max_cnt_f1_ac0[6:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 31. "       rfdll_max_pulse_ac0 ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_top_ch0 @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 137(0x89)" 
    VARX 0x00 %l SWD.read(0x00890000)
    TEXTLINE ""
    LINE.LONG 0x00 "  "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--6. " rfdll_min_cnt_f2_ac1[6:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 7. "       rfdll_min_pulse_ac0 ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--14. " rfdll_max_cnt_f2_ac1[6:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "       rfdll_max_pulse_ac1 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--22. " rfdll_min_cnt_f3_ac1[6:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 23. "       rfdll_min_pulse_ac0 ," "0    ,%d..."
    BITFLD.LONG 0x00 24.--30. " rfdll_max_cnt_f3_ac1[6:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 31. "       rfdll_max_pulse_ac1 ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_top_ch0 @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 138(0x8a)" 
    VARX 0x00 %l SWD.read(0x008A0000)
    TEXTLINE ""
    LINE.LONG 0x00 "  "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--6. " rfdll_min_cnt_f4_ds1[6:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 7. "       rfdll_min_pulse_ds1 ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--14. " rfdll_max_cnt_f4_ds1[6:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "       rfdll_max_pulse_ds1 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--22. " rfdll_min_cnt_f5_ds0[6:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 23. "       rfdll_min_pulse_ds0 ," "0    ,%d..."
    BITFLD.LONG 0x00 24.--30. " rfdll_max_cnt_f5_ds0[6:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 31. "       rfdll_max_pulse_ds0 ," "0    ,%d..."
    TEXTLINE ""
    SGROUP "pub_top_pwr_wrap.u_pub_top.u_ddrc_wrap.u_ddrc_phy_top_ch0 @ "
;-------------------------------------------------
    TEXTLINE ""
    TEXTLINE "subsys 0(0x0) mod 0(0x0) sig 139(0x8b)" 
    VARX 0x00 %l SWD.read(0x008B0000)
    TEXTLINE ""
    LINE.LONG 0x00 "  "
    TEXTLINE ""
    TEXTLINE ""
    BITFLD.LONG 0x00 0.--6. " rfdll_min_cnt_f6_ds3[6:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 7. "       rfdll_min_pulse_ds3 ," "0    ,%d..."
    BITFLD.LONG 0x00 8.--14. " rfdll_max_cnt_f6_ds3[6:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 15. "       rfdll_max_pulse_ds3 ," "0    ,%d..."
    TEXTLINE ""
    BITFLD.LONG 0x00 16.--22. " rfdll_min_cnt_f7_ds2[6:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 23. "       rfdll_min_pulse_ds2 ," "0    ,%d..."
    BITFLD.LONG 0x00 24.--30. " rfdll_max_cnt_f7_ds2[6:0] ," "0    ,%d..."
    BITFLD.LONG 0x00 31. "       rfdll_max_pulse_ds2 ," "0    ,%d..."
    TEXTLINE ""
TREE.END
