LOCAL &CUR_DIR
&CUR_DIR=OS.PPD()

