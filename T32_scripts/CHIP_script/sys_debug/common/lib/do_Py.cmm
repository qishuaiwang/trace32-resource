DO &lib_do_cmd &lib_py &project_sel
